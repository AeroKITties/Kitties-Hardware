File: Hardware/ciam/impeller/impeller/switches.kicad_sch (KiCad schematic)
At the start: 57 parts, among them J7 Micro-Fit_2x5P, J8 Micro-Fit_2x5P, J9 Micro-Fit_2x5P, U18 TLP291, U19 TLP291, U20 TLP291, U21 TLP291, U22 TLP291, U24 TLP291, U25 TLP291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

Commit message: updated piezo module
Parts:
- renumbered C16 to C44, C14 to C45, C16 to C46, C14 to C47, C16 to C48, C14 to C49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
