File: Hardware/ciam/impeller/impeller/indicators.kicad_sch (KiCad schematic)
At the start: 22 parts, among them J5 Micro-Fit_2x5P, J6 Micro-Fit_2x5P, U2 G3VM61D1

Commit message: updated piezo module
Parts:
- renumbered U2 to U10, U2 to U11, U2 to U12, U2 to U13, U2 to U14, U2 to U15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
