File: Hardware/ciam/impeller/impeller/impeller.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: updated ciam project
Parts:
- added C1, C2: 2u2, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added C10: 4u7, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added C11, C12, C13, C14, C15, C16, C17, C3, C6, C8: 100n, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added C4, C5: 8p, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added C7, C9: 1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added J1: Pinheader_1x3, symbol Connector_Generic:Conn_01x03
- added R1: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R2: 0, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added SW1: NRST_SW, Button_Switch_THT:SW_PUSH_6mm_H4.3mm, symbol Switch:SW_Push
- added U1: STM32F405VGT6, Package_QFP:LQFP-100_14x14mm_P0.5mm, symbol MCU_ST_STM32F4:STM32F405VGTx
- added Y1: 16M, Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering, symbol Device:Crystal_GND24
Connections:
- new net: C1.1, U1.49 (VCAP_1)
- new net: C2.1, U1.73 (VCAP_2)
- new net: C4.1, R2.1, Y1.1
- new net: J1.2 (Pin_2), R1.1
- new net BOOT0: R1.2, U1.94 (BOOT0)
- new net CAN1_RX: U1.81 (PD0)
- new net CAN1_TX: U1.82 (PD1)
- new net CAN2_RX: U1.91 (PB5)
- new net CAN2_TX: U1.92 (PB6)
- new net GND: C1.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C2.2, C3.2, C4.2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
- new net HSE_IN: R2.2, U1.12 (PH0)
- new net HSE_OUT: C5.1, U1.13 (PH1), Y1.3
- new net NRST: C3.1, SW1.1, U1.14 (NRST)
- new net SWD_SWCLK: U1.76 (PA14)
- new net SWD_SWDIO: U1.72 (PA13)
- new net SWD_SWO: U1.89 (PB3)
- new net USART3_RX: U1.56 (PD9)
- new net USART3_TX: U1.55 (PD8)
- new net USB_D+: U1.70 (PA11)
- new net USB_D-: U1.71 (PA12)
- new net VDD_3V3: C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C6.1, C7.1, C8.1, C9.1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
Other:
- added sheet Encoders (encoders.kicad_sch)
- added sheet General connectors (connectors.kicad_sch)
- added sheet Indicators (indicators.kicad_sch)
- added sheet Switches (switches.kicad_sch)
- note added: "BOOT0"
- note added: "Decoupling capacitors"
- note added: "HSE"
- note added: "RESET"
- note added: "VDD (pins 11,19,28,50,75,100) VBAT (pin 6)"
- note added: "VDDA (pin 22)"
- note added: "VREF+ (pin 21)"

Commit message: multiple fixes
Parts:
- removed C17: 100n, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- removed C4, C5: 8p, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- removed R2: 0, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added BT1: KLS5-CR2032-01, symbol Device:Battery_Cell
- added C1: 100n, Capacitor_SMD:C_0603_1608Metric, symbol Device:C_Small
- added C13, C14, C16, C17: 15p, Capacitor_SMD:C_0603_1608Metric, symbol Device:C_Small
- added J10: Micro-Fit_2x5P F, symbol Connector_Generic:Conn_02x05_Odd_Even
- added J2: Micro-Fit_2x2P F, symbol Connector_Generic:Conn_02x02_Odd_Even
- added J9: Micro-Fit_2x12P F, symbol Connector_Generic:Conn_02x12_Odd_Even
- added JP1: PLS-2, symbol Jumper:Jumper_2_Open
- added R2: 0, Resistor_SMD:R_0603_1608Metric, symbol Device:R_Small
- added Y1: KSE-7K32768KDY2400A3, symbol Device:Crystal
- C1, C2: Ссылка (none) -> https://www.chipdip.ru/product/grm188r61a225k; Цена (none) -> 11
- C10: Ссылка (none) -> https://www.chipdip.ru/product0/9000348448; Цена (none) -> 21
- C11, C12, C13, C14, C15, C16, C3, C6, C8: Ссылка (none) -> https://www.chipdip.ru/product/grm188r71h104k; Цена (none) -> 19
- C7, C9: Ссылка (none) -> https://www.chipdip.ru/product/grm188r71c105ka12d; Цена (none) -> 20
- J1: value Pinheader_1x3 -> PLS-3; Ссылка (none) -> https://www.chipdip.ru/product/pls-3; Цена (none) -> 8
- R1: footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0805_2012Metric; Ссылка (none) -> https://www.chipdip.ru/product/0.125w-0805-10-kom-5; Цена (none) -> 5
- SW1: value NRST_SW -> KLS7-TS6601-11-180; Ссылка (none) -> https://www.chipdip.ru/product/kls7-ts6601-11.0-180-it-1102k; Цена (none) -> 8
- U1: Ссылка (none) -> https://www.chipdip.ru/product0/8884285457; Цена (none) -> 930
- Y1: value 16M -> KSE-7U08000MAB143ZA3; Ссылка (none) -> https://www.chipdip.ru/product0/8022069891; Цена (none) -> 12
Connections:
- net GND: now also BT1.2 (-), C1.1, C13.1, C14.1, C16.1, C17.1
- net HSE_IN: now also R2.2
- net HSE_OUT: now also Y1.1, C17.2; no longer Y1.3
- net VDD_3V3: now also JP1.2 (B); no longer U1.6 (VBAT)
- net LSE_IN: now reaches U1.8 (PC14)
- net LSE_IN: now also C13.2, Y1.2
- net LSE_OUT: now reaches U1.9 (PC15)
- net LSE_OUT: now also C16.2, Y1.1
- new net: BT1.1 (+), C1.2, JP1.1 (A), U1.6 (VBAT)
- new net: C14.2, R2.1, Y1.3
Other:
- note added: "12.5pF"
- note added: "LSE"
- note added: "VDD (pins 11,19,28,50,75,100)"
- note removed: "VDD (pins 11,19,28,50,75,100) VBAT (pin 6)"
- moved on the sheet: C1, C10, C11, C12, C13, C14, C15, C16, C2, C3, C6, C7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

Commit message: updated bom
Parts:
- BT1: Человекопонятное название (none) -> Разъем для плоской батарейки 3В
- C1, C2: Человекопонятное название (none) -> Конденсатор 2.2мкФ
- C1, C11, C12, C13, C14, C15, C16, C3, C6, C8: Человекопонятное название (none) -> Конденсатор 100нФ
- C10: Человекопонятное название (none) -> Конденсатор 4.7мкФ
- C13, C14, C16, C17: Человекопонятное название (none) -> Конденсатор 15пФ
- C7, C9: Человекопонятное название (none) -> Конденсатор 1мкФ
- J1: Человекопонятное название (none) -> Вилка штыревая 1x3
- J10: Человекопонятное название (none) -> Разъем Micro-Fit 2x5 Ж
- J2: Человекопонятное название (none) -> Разъем Micro-Fit 2x2 Ж
- J9: Человекопонятное название (none) -> Разъем Micro-Fit 2x12 Ж
- JP1: Человекопонятное название (none) -> Вилка штыревая 1x2
- R1: Человекопонятное название (none) -> Резистор 10k Ом
- R2: Человекопонятное название (none) -> Резистор 0 ОМ (перемычка)
- SW1: Человекопонятное название (none) -> Кнопка тактовая прямая
- U1: Человекопонятное название (none) -> Микроконтроллер
- Y1: Человекопонятное название (none) -> Кристаллический резонатор 8МГц
- Y1: Человекопонятное название (none) -> Кристаллический резонатор 32КГц
Changed lines of the file:
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@@
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Человекопонятное название" "Конденсатор 2.2мкФ" (at 22.86 170.815 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 100нФ" (at 180.34 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Цена" "11" (at 32.385 170.815 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Человекопонятное название" "Конденсатор 2.2мкФ" (at 32.385 170.815 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Разъем Micro-Fit 2x2 Ж" (at 137.16 100.33 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Цена" "60" (at 161.925 112.395 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Человекопонятное название" "Разъем Micro-Fit 2x12 Ж" (at 161.925 112.395 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 100нФ" (at 41.91 36.195 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 100нФ" (at 159.385 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 1мкФ" (at 190.5 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Цена" "12" (at 252.095 77.47 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Человекопонятное название" "Кристаллический резонатор 8МГц" (at 252.095 77.47 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Резистор 10k Ом" (at 128.905 33.02 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 15пФ" (at 242.57 69.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Вилка штыревая 1x3" (at 141.605 33.02 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 100нФ" (at 138.43 72.39 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 100нФ" (at 242.57 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 100нФ" (at 262.89 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Цена" "33" (at 137.16 117.475 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Человекопонятное название" "Разъем Micro-Fit 2x5 Ж" (at 137.16 117.475 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 15пФ" (at 242.57 85.09 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 15пФ" (at 190.5 80.645 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 1мкФ" (at 169.545 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Цена" "19" (at 252.73 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Человекопонятное название" "Конденсатор 100нФ" (at 252.73 38.1 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 15пФ" (at 190.5 67.945 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Цена" "8" (at 149.225 72.39 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Человекопонятное название" "Кнопка тактовая прямая" (at 149.225 72.39 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Кристаллический резонатор 32КГц" (at 197.485 74.295 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Резистор 0 ОМ (перемычка)" (at 261.62 69.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Цена" "19" (at 232.41 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Человекопонятное название" "Конденсатор 100нФ" (at 232.41 38.1 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Вилка штыревая 1x2" (at 57.785 27.305 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 100нФ" (at 222.25 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
     )
     (property "Цена" "19" (at 212.09 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Человекопонятное название" "Конденсатор 100нФ" (at 212.09 38.1 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
     (property "Цена" "930" (at 59.055 110.49 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Человекопонятное название" "Микроконтроллер" (at 59.055 110.49 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Конденсатор 4.7мкФ" (at 201.93 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Человекопонятное название" "Разъем для плоской батарейки 3В" (at 40.005 27.305 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: updated component info
Parts:
- removed J10: Micro-Fit_2x5P F, symbol Connector_Generic:Conn_02x05_Odd_Even
- removed J2: Micro-Fit_2x2P F, symbol Connector_Generic:Conn_02x02_Odd_Even
- removed J9: Micro-Fit_2x12P F, symbol Connector_Generic:Conn_02x12_Odd_Even

Commit message: Updated CIAM project
Parts:
- added H1 (x2): MH_M3_Corner, user_lib:MountingHole_3.2mm_M3_Pad_Via_5mm, symbol Mechanical:MountingHole
- BT1: footprint (none) -> user_lib:KLS5-CR2032-01
- J1: footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical
- JP1: footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical
- Y1: footprint Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering -> user_lib:KSE-7U08000MAB143ZA3
- Y1: footprint (none) -> user_lib:KSE-7K32768KDY2400A3
Connections:
- net USB_D+: now also U1.71 (PA12); no longer U1.70 (PA11)
- net USB_D-: now also U1.70 (PA11); no longer U1.71 (PA12)
- net SDIO_DAT0: now reaches U1.65 (PC8)
- net SDIO_DAT1: now reaches U1.66 (PC9)
- net SDIO_DAT2: now reaches U1.78 (PC10)
- net SDIO_DAT3: now reaches U1.79 (PC11)
- net SDIO_CLK: now reaches U1.80 (PC12)
- net SDIO_CMD: now reaches U1.83 (PD2)
- net SD_CD: now reaches U1.84 (PD3)
