File: Hardware/ciam/impeller18/adc.kicad_sch (KiCad schematic)
At the start: 47 parts, among them J14 430451600, Q30 BSS138, U48 B0505MT-1WR4, U49 HCPL-0600, U50 MCP3008, U51 HCPL-0630, U52 IP4220, U53 HCPL-0600, U54 IP4220

Commit message: updated schematics
Parts:
- removed R157: 150, symbol Device:R_Small
- added R182: 360, symbol Device:R_Small
- C90: renamed from C82; Ссылка https://www.chipdip.ru/product/grm21br71h104k -> (none); Цена 13 -> (none); Человекопонятное название Конденсатор 100нФ -> (none)
- C91: renamed from C83; Ссылка https://www.chipdip.ru/product/grm21br61e106ka73l -> (none); Цена 13 -> (none); Человекопонятное название Конденсатор 10мкФ -> (none)
- C92: renamed from C84; Ссылка https://www.chipdip.ru/product/grm21br61e106ka73l -> (none); Цена 13 -> (none); Человекопонятное название Конденсатор 10мкФ -> (none)
- C93: renamed from C85; Ссылка https://www.chipdip.ru/product/grm21br71h104k -> (none); Цена 13 -> (none); Человекопонятное название Конденсатор 100нФ -> (none)
- J15: renamed from J14; footprint (none) -> Connector_Molex:Molex_Micro-Fit_3.0_43045-1600_2x08_P3.00mm_Horizontal
- Q34: renamed from Q30; Ссылка https://www.chipdip.ru/product/bss138-umw -> (none); Цена 3 -> (none); Человекопонятное название Транзистор полевой n типа -> (none)
- R205: renamed from R180; Ссылка https://www.chipdip.ru/product/0.125w-0805-10-kom-5 -> (none); Цена 5 -> (none); Человекопонятное название Резистор 10k Ом -> (none)
- R206: renamed from R181; Ссылка https://www.chipdip.ru/product/0.125w-0805-10-kom-5 -> (none); Цена 5 -> (none); Человекопонятное название Резистор 10k Ом -> (none)
- U55: renamed from U48; Ссылка https://www.chipdip.ru/product0/8003333290 -> (none); Цена 120 -> (none); Человекопонятное название DC/DC преобразователь -> (none)
- renumbered C86 to C94, C87 to C95, D11 to D18, R158 to R183, R159 to R184, R160 to R185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
Connections:
- net 5V0_ADC: now also R182.2
- net at D18.2 (A): now also R182.1

Commit message: updated schematics
Parts:
- C90, C93, C94, C95: Мин. кол-во (none) -> 300; Ссылка (none) -> https://www.promelec.ru/product/323633/; Цена (none) -> 2; Человекопонятное название (none) -> Керамический ЧИП-конденсатор 0603 X7R 0.1мкФ
- C91, C92: Мин. кол-во (none) -> 200; Ссылка (none) -> https://www.promelec.ru/product/430347/; Цена (none) -> 4; Человекопонятное название (none) -> Керамический ЧИП-конденсатор 0603 X5R 10мкФ
- D18: footprint (none) -> LED_SMD:LED_0603_1608Metric; Мин. кол-во (none) -> 3; Ссылка (none) -> https://www.promelec.ru/product/324327/; Цена (none) -> 5; Человекопонятное название (none) -> Светодиод smd 1,6х0,8мм/зеленый/568нм/65мкд/прозрачный/130°
- J18: renamed from J15; footprint Connector_Molex:Molex_Micro-Fit_3.0_43045-1600_2x08_P3.00mm_Horizontal -> (none); Мин. кол-во (none) -> 3; Ссылка (none) -> https://www.promelec.ru/product/362588/; Цена (none) -> 197; Человекопонятное название (none) -> Прямоугольный разъем, Серия Micro-Fit 3.0 43045, 16 контакт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
- Q36: renamed from Q34; footprint Package_TO_SOT_SMD:SOT-23 -> (none); Мин. кол-во (none) -> 38; Ссылка (none) -> https://www.promelec.ru/product/303635/; Цена (none) -> 14; Человекопонятное название (none) -> Транзистор полевой N-канальный
- R190: renamed from R182; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/46471/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 360Ом
- R191: renamed from R183; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/22010/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 1МОм
- R192: renamed from R184; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/57740/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 200кОм
- R193: renamed from R185; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/22010/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 1МОм
- R194: renamed from R186; Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R195: renamed from R187; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/57740/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 200кОм
- R196: renamed from R188; Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R198: renamed from R190; Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R199: renamed from R191; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/22010/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 1МОм
- R200: renamed from R192; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/57740/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 200кОм
- R202: renamed from R194; Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R203: renamed from R195; Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R204: renamed from R196; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/22010/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 1МОм
- R205: renamed from R197; Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R206: renamed from R198; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/57740/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 200кОм
- R208: renamed from R200; Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R209: renamed from R201; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/22010/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 1МОм
- R210: renamed from R202; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/57740/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 200кОм
- R211: renamed from R203; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/22010/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 1МОм
- R212: renamed from R204; Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R213: renamed from R205; footprint Resistor_SMD:R_0805_2012Metric -> (none); Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R214: renamed from R206; footprint Resistor_SMD:R_0805_2012Metric -> (none); Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
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
Commit message: updatec schematics
Parts:
- added TP27, TP28: TestPoint, symbol Connector:TestPoint
- R197, R201, R207: value R_Small -> 180; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/108141/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 180Ом
Connections:
- net 5V0_ADC: now also TP27.1
- net GND_ADC: now also TP28.1
