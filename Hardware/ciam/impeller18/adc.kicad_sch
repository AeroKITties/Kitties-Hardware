File: Hardware/ciam/impeller18/adc.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: updated impeller18 schamatic
Parts:
- added C54, C57, C62, C63: 100n, symbol Device:C_Small
- added C55, C56: 10u, symbol Device:C_Small
- added C58: 1u, symbol Device:C
- added C59, C61: 100n, symbol Device:C
- added C60: 4u7, symbol Device:C
- added R145, R147, R153, R158, R160, R165, R167, R169: 1M, symbol Device:R_Small
- added R146, R151, R155, R159, R164, R166, R168, R170: 110k, symbol Device:R_Small
- added R148, R150, R154, R156, R161, R163: 1k, symbol Device:R_Small
- added R149, R152, R157, R162: 150, symbol Device:R_Small
- added U33: LDL1117S33R, symbol Regulator_Linear:LD1117S33TR_SOT223
- added U34: B0505MT-1WR4, symbol Interface_CAN_LIN:ISO1050DUB
- added U35, U38: HCPL-0600, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol Isolator:HCPL-0600
- added U36: MCP3008, symbol Analog_ADC:MCP3008
- added U37: HCPL-0630, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol Isolator:HCPL-0630
Connections:
- new net: R161.2, U38.7 (EN)
- new net: R150.2, U35.7 (EN)
- new net: R152.2, U37.1 (A1)
- new net: R156.2, U36.10 (~{CS}/SHDN), U37.6 (VO2)
- new net: R154.1, U36.11 (Din), U37.7 (VO1)
- new net: U36.12 (Dout), U38.3 (C)
- new net: R148.1, U35.6 (VO), U36.13 (CLK)
- new net: R157.1, U37.4 (A2)
- new net: R149.1, U35.2 (A)
- new net: R162.1, U38.2 (A)
- new net 3V3: R149.2, R152.1, R157.2, R161.1, R163.2, U38.8 (VCC)
- new net 3V3_ADC: C60.1, C61.1, C62.1, C63.1, R148.2, R150.1, R154.2, R156.1, R162.2, U33.2 (VO), U35.8 (VCC), U36.15 (Vref)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
- new net 5V0: C56.1, C57.1, U34.13 (Vin), U34.14 (Vin)
- new net 5V0_ADC: C54.1, C55.1, C58.1, C59.1, U33.3 (VI), U34.8 (+Vo)
- new net ADC_30V_IN_1: R145.1
- new net ADC_30V_IN_2: R147.1
- new net ADC_30V_IN_3: R153.1
- new net ADC_30V_IN_4: R158.1
- new net ADC_30V_IN_5: R160.1
- new net ADC_30V_IN_6: R165.1
- new net ADC_30V_IN_7: R167.1
- new net ADC_30V_IN_8: R169.1
- new net ADC_3V3_IN_1: R145.2, R146.2, U36.1 (CH0)
- new net ADC_3V3_IN_2: R147.2, R151.2, U36.2 (CH1)
- new net ADC_3V3_IN_3: R153.2, R155.2, U36.3 (CH2)
- new net ADC_3V3_IN_4: R158.2, R159.2, U36.4 (CH3)
- new net ADC_3V3_IN_5: R160.2, R164.2, U36.5 (CH4)
- new net ADC_3V3_IN_6: R165.2, R166.2, U36.6 (CH5)
- new net ADC_3V3_IN_7: R167.2, R168.2, U36.7 (CH6)
- new net ADC_3V3_IN_8: R169.2, R170.2, U36.8 (CH7)
- new net ADC_CS: U37.3 (C2)
- new net GND: C56.2, C57.2, U34.1 (gnd), U34.2 (gnd), U38.5 (GND)
- new net GND_ADC: C54.2, C55.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, R146.1, R151.1, R155.1, R159.1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
- new net SPI_CLK: U35.3 (C)
- new net SPI_MISO: R163.1, U38.6 (VO)
- new net SPI_MOSI: U37.2 (C1)
Other:
- note added: "!!! Добавить разъем и защиту от esd"

Commit message: updated schematics
Parts:
- added J11: 430451600, symbol Connector_Generic:Conn_02x08_Odd_Even
- added U41, U43: ~, symbol user_lib:IP4220
- U38: renamed from U35; footprint Package_SO:SOIC-8_3.9x4.9mm_P1.27mm -> (none)
- U40: renamed from U37; footprint Package_SO:SOIC-8_3.9x4.9mm_P1.27mm -> (none)
- U42: renamed from U38; footprint Package_SO:SOIC-8_3.9x4.9mm_P1.27mm -> (none)
- renumbered C54 to C83, C55 to C84, C56 to C85, C57 to C86, C58 to C87, C59 to C88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
Connections:
- net 3V3_ADC: now also U41.5 (VDD), U43.5 (VDD)
- net ADC_30V_IN_1: now also J11.1 (Pin_1)
- net ADC_30V_IN_2: now also J11.5 (Pin_5)
- net ADC_30V_IN_3: now also J11.3 (Pin_3)
- net ADC_30V_IN_4: now also J11.7 (Pin_7)
- net ADC_30V_IN_5: now also J11.9 (Pin_9)
- net ADC_30V_IN_6: now also J11.11 (Pin_11)
- net ADC_30V_IN_7: now also J11.13 (Pin_13)
- net ADC_30V_IN_8: now also J11.15 (Pin_15)
- net ADC_3V3_IN_1: now also U41.1 (IO1)
- net ADC_3V3_IN_2: now also U41.3 (IO2)
- net ADC_3V3_IN_3: now also U41.4 (IO3)
- net ADC_3V3_IN_4: now also U41.6 (IO4)
- net ADC_3V3_IN_5: now also U43.1 (IO1)
- net ADC_3V3_IN_6: now also U43.3 (IO2)
- net ADC_3V3_IN_7: now also U43.4 (IO3)
- net ADC_3V3_IN_8: now also U43.6 (IO4)
- net GND_ADC: now also J11.10 (Pin_10), J11.12 (Pin_12), J11.14 (Pin_14), J11.16 (Pin_16), J11.2 (Pin_2), J11.4 (Pin_4), J11.6 (Pin_6), J11.8 (Pin_8), U41.2 (GND), U43.2 (GND)
- net ADC_CS renamed SPI1_STM32_ADC8_CS
- net SPI_CLK renamed SPI1_STM32_CLK
- net SPI_MISO renamed SPI1_STM32_MISO
- net SPI_MOSI renamed SPI1_STM32_MOSI
Other:
- note removed: "!!! Добавить разъем и защиту от esd"
- moved on the sheet: C83, C84, C85, C86, C87, C88, C89, C90, C91, C92, R148, R149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

Commit message: updated impeller18 schematics
Parts:
- removed C87: 1u, symbol Device:C
- removed C88, C90: 100n, symbol Device:C
- removed C89: 4u7, symbol Device:C
- removed R171, R173: 110k, symbol Device:R_Small
- removed U36: LDL1117S33R, symbol Regulator_Linear:LD1117S33TR_SOT223
- added Q31: BSS138, Package_TO_SOT_SMD:SOT-23, symbol Transistor_FET:BSS138
- added R231, R232, R233, R234: 10k, symbol Device:R_Small
- added R235, R236: 10k, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small
- R149, R154, R158, R162, R167, R169: value 110k -> 200k
- R151, R157, R159: value 1k -> 10k
- R152: value 150 -> 10k
- R153: value 1k -> 200k
- R155: value 150 -> 200k
- R160: value 150 -> 470
- R164, R166: value 1k -> R_Small
- R165: value 150 -> R_Small
- U41, U43: value ~ -> IP4220
Connections:
- net 3V3: now also R164.2, R165.2, Q31.1 (G), R231.1, R232.1, R233.1, R236.1; no longer R152.2, R155.1, R160.2, R164.1, U42.8 (VCC)
- net 5V0: now also U42.8 (VCC), R234.1, R235.1
- net 5V0_ADC: now also C91.1, C92.1, R151.1, R152.2, R157.1, R159.2, R160.1, U38.8 (VCC), U39.15 (Vref), U39.16 (Vdd), U40.8 (VCC), U41.5 (VDD)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
- net ADC_30V_IN_1: no longer R148.1
- net ADC_30V_IN_2: no longer R150.1
- net ADC_30V_IN_3: no longer R156.1
- net ADC_30V_IN_4: no longer R161.1
- net ADC_30V_IN_5: no longer R163.1
- net ADC_30V_IN_6: no longer R168.1
- net ADC_30V_IN_7: no longer R170.1
- net ADC_30V_IN_8: no longer R172.1
- net GND_ADC: now also R153.1, R155.1
- net SPI1_STM32_ADC8_CS: now also R233.2
- net SPI1_STM32_CLK: now also R231.2
- net SPI1_STM32_MISO: now also Q31.2 (S), R236.2; no longer R166.1, U42.6 (VO)
- net SPI1_STM32_MOSI: now also R232.2
- net at U42.7 (EN): now also R234.2; no longer R164.2
- net at U38.7 (EN): now also R151.2; no longer R153.2
- net at U40.1 (A1): now also R164.1; no longer R155.2
- net SPI_ADC8_CS: now reaches U39.10 (~{CS}/SHDN), U40.6 (VO2)
- net SPI_ADC8_CS: now also R159.1; no longer R159.2
- net SPI_ADC8_MOSI: now reaches U39.11 (Din), U40.7 (VO1)
- net SPI_ADC8_MOSI: now also R157.2; no longer R157.1
- net SPI_ADC8_MISO: now reaches U39.12 (Dout), U42.3 (C)
- net SPI_ADC8_CLK: now reaches U38.6 (VO), U39.13 (CLK)
- net SPI_ADC8_CLK: now also R152.1; no longer R151.1
- net at U40.4 (A2): now also R165.1; no longer R160.1
- net at U38.2 (A): now also R166.1; no longer R152.1
- net at U42.2 (A): now also R160.2; no longer R165.1
- removed net 3V3_ADC: C91.1, C92.1, R151.2, R153.1, R157.2, R159.1, R165.2, U38.8 (VCC), U39.15 (Vref), U39.16 (Vdd), U40.8 (VCC), U41.5 (VDD)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
- net ADC_3V3_IN_1 renamed ADC_5V_1
- net ADC_3V3_IN_2 renamed ADC_5V_2
- net ADC_5V_2: now also R153.2; no longer R154.2
- net ADC_3V3_IN_3 renamed ADC_5V_3
- net ADC_5V_3: now also R154.2; no longer R158.2
- net ADC_3V3_IN_4 renamed ADC_5V_4
- net ADC_5V_4: now also R155.2; no longer R162.2
- net ADC_3V3_IN_5 renamed ADC_5V_5
- net ADC_5V_5: now also R158.2; no longer R167.2
- net ADC_3V3_IN_6 renamed ADC_5V_6
- net ADC_5V_6: now also R162.2; no longer R169.2
- net ADC_3V3_IN_7 renamed ADC_5V_7
- net ADC_5V_7: now also R169.2
- net ADC_3V3_IN_8 renamed ADC_5V_8
- net ADC_5V_8: now also R167.2
- new net: Q31.3 (D), R235.2, U42.6 (VO)
- new net ADC_30V_1: R148.1
- new net ADC_30V_2: R150.1
- new net ADC_30V_3: R156.1
- new net ADC_30V_4: R161.1
- new net ADC_30V_5: R163.1
- new net ADC_30V_6: R168.1
- new net ADC_30V_7: R170.1
- new net ADC_30V_8: R172.1
Other:
- moved on the sheet: C83, C84, C85, C86, C91, C92, J11, R148, R149, R150, R156, R161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

Commit message: updated schematics
Parts:
- added D11: FYLS-0603BUGC, symbol Device:LED
- added R157: 150, symbol Device:R_Small
- renumbered C83 to C82, C84 to C83, C85 to C84, C86 to C85, C91 to C86, C92 to C87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
Connections:
- net 5V0_ADC: now also R157.1
- net GND_ADC: now also D11.1 (K)
- new net: D11.2 (A), R157.2
