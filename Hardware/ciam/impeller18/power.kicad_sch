File: Hardware/ciam/impeller18/power.kicad_sch (KiCad schematic)
At the start: 111 parts, among them J30 PLS-2, J31 PLS-2, J4 430450400, K1 1-1415899-9, K2 1-1415899-9, K3 1-1415899-9, Q1 BSS138, Q2 AO3401A, Q3 BSS138, Q39 BSS138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

Commit message: Updated packeges
Parts:
- BT2, BT3: footprint (none) -> user_lib:bat_18350
Changed lines of the file:
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@@
 			)
 		)
-		(property "Footprint" ""
+		(property "Footprint" "user_lib:bat_18350"
 			(at 302.26 177.546 90)
 			(effects
@@
 			)
 		)
-		(property "Footprint" ""
+		(property "Footprint" "user_lib:bat_18350"
 			(at 302.26 147.066 90)
 			(effects

Commit message: Updated 3D models
Parts:
- K1: renamed from K3; value 1-1415899-9 -> 1393219-3; footprint user_lib:1-1415899-9 -> user_lib:1393219-3; Ссылка https://www.promelec.ru/product/320600/ -> https://www.promelec.ru/product/320571/; Цена 272 -> 280
- K2: renamed from K1; value 1-1415899-9 -> 1393219-3; footprint user_lib:1-1415899-9 -> user_lib:1393219-3; Ссылка https://www.promelec.ru/product/320600/ -> https://www.promelec.ru/product/320571/; Цена 272 -> 280
- K3: renamed from K2; value 1-1415899-9 -> 1393219-3; footprint user_lib:1-1415899-9 -> user_lib:1393219-3; Ссылка https://www.promelec.ru/product/320600/ -> https://www.promelec.ru/product/320571/; Цена 272 -> 280
- U3: renamed from U7; Ссылка https://www.chipdip.ru/product0/8010031104 -> https://voltbricks.nt-rt.ru/price/product/1132916; Цена 7 890 -> 3 947
- U4: Ссылка https://www.chipdip.ru/product0/8010031081 -> https://voltbricks.nt-rt.ru/price/product/1132885; Цена 8100 -> 3 045
- renumbered C29 to C27, C30 to C28, C31 to C29, C32 to C30, C129 to C31, C128 to C32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

Commit message: updated bom
Parts:
- added C56, C59: 4u7, Capacitor_SMD:C_1210_3225Metric, symbol Device:C_Small
- C36, C47, C49: footprint Capacitor_THT:CP_Radial_D12.5mm_P5.00mm -> Capacitor_THT:CP_Radial_D10.0mm_P5.00mm; Мин. кол-во 9 -> 10; Ссылка https://www.promelec.ru/product/381508/ -> https://www.promelec.ru/product/601218/; Цена 60 -> 52; Человекопонятное название Конденсатор алюминиевый электролитический 47мкФ 200В -> конденсатор алюминиевый электролитический 47мкф 100в
- renumbered C56 to C57, C57 to C58, C58 to C60, C59 to C61, C60 to C62, C61 to C63
Connections:
- net 7V4: now also C56.2
- net GND: now also C56.1, C59.2
- net at C58.1, D7.2 (A), R29.1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: now also C59.1
Other:
- moved on the sheet: C58, TP18, TP19

Commit message: PCB concept
Parts:
- J6: footprint user_lib:430454000 -> user_lib:430450400
Connections:
- net GND_IN: now also J6.3 (Pin_3); no longer J6.2 (Pin_2)
- net VIN: now also J6.2 (Pin_2); no longer J6.3 (Pin_3)
Changed lines of the file:
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@@
 	)
 	(junction
-		(at 27.305 26.035)
-		(diameter 0)
-		(color 0 0 0 0)
-	)
-	(junction
 		(at 35.56 48.26)
 		(diameter 0)
@@
 	)
 	(junction
-		(at 29.845 138.43)
+		(at 37.465 32.385)
 		(diameter 0)
 		(color 0 0 0 0)
 	)
 	(junction
-		(at 47.625 28.575)
+		(at 29.845 138.43)
 		(diameter 0)
 		(color 0 0 0 0)
@@
 		(color 0 0 0 0)
 	)
+	(junction
+		(at 37.465 18.415)
+		(diameter 0)
+		(color 0 0 0 0)
+	)
 	(no_connect
 		(at 132.715 90.17)
@@
 	(wire
 		(pts
+			(xy 28.575 32.385) (xy 28.575 28.575)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 200.025 87.63) (xy 200.025 83.82)
 		)
@@
 	(wire
 		(pts
+			(xy 37.465 32.385) (xy 37.465 33.655)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
+			(xy 37.465 32.385) (xy 28.575 32.385)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 334.645 214.63) (xy 334.645 219.075)
 		)
@@
 	(wire
 		(pts
-			(xy 47.625 31.115) (xy 47.625 28.575)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 166.37 194.31) (xy 185.42 194.31)
 		)
@@
 	(wire
 		(pts
+			(xy 37.465 18.415) (xy 46.355 18.415)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 29.845 138.43) (xy 29.845 149.86)
 		)
@@
 	(wire
 		(pts
-			(xy 27.305 26.035) (xy 27.305 28.575)
+			(xy 166.37 189.865) (xy 166.37 194.31)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 166.37 189.865) (xy 166.37 194.31)
+			(xy 224.79 113.03) (xy 229.235 113.03)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 224.79 113.03) (xy 229.235 113.03)
+			(xy 37.465 18.415) (xy 28.575 18.415)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 31.115 26.035) (xy 27.305 26.035)
+			(xy 31.115 26.035) (xy 28.575 26.035)
 		)
 		(stroke
@@
 	(wire
 		(pts
+			(xy 37.465 32.385) (xy 46.355 32.385)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 102.87 52.07) (xy 102.87 48.26)
 		)
@@
 	(wire
 		(pts
-			(xy 43.815 26.035) (xy 47.625 26.035)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 75.565 177.8) (xy 75.565 181.61)
 		)
@@
 	(wire
 		(pts
+			(xy 46.355 32.385) (xy 46.355 28.575)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 125.095 40.64) (xy 193.04 40.64)
 		)
@@
 	(wire
 		(pts
+			(xy 31.115 28.575) (xy 28.575 28.575)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 42.545 161.925) (xy 55.88 161.925)
 		)
@@
 	(wire
 		(pts
-			(xy 27.305 23.495) (xy 27.305 26.035)
+			(xy 37.465 17.145) (xy 37.465 18.415)
 		)
 		(stroke
@@
 	(wire
 		(pts
+			(xy 43.815 28.575) (xy 46.355 28.575)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 130.81 52.07) (xy 130.81 49.53)
 		)
@@
 	(wire
 		(pts
+			(xy 43.815 26.035) (xy 46.355 26.035)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 200.025 46.99) (xy 200.025 48.26)
 		)
@@
 	(wire
 		(pts
-			(xy 47.625 28.575) (xy 47.625 26.035)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 185.42 184.785) (xy 185.42 194.31)
 		)
@@
 	(wire
 		(pts
-			(xy 43.815 28.575) (xy 47.625 28.575)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 354.33 87.63) (xy 362.585 87.63)
 		)
@@
 	(wire
 		(pts
-			(xy 31.115 28.575) (xy 27.305 28.575)
+			(xy 80.01 48.26) (xy 91.44 48.26)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 80.01 48.26) (xy 91.44 48.26)
+			(xy 28.575 18.415) (xy 28.575 26.035)
 		)
 		(stroke
@@
 	(wire
 		(pts
+			(xy 46.355 18.415) (xy 46.355 26.035)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 45.085 96.52) (xy 54.61 96.52)
 		)
@@
 	(symbol
 		(lib_id "power:GND")
-		(at 47.625 31.115 0)
+		(at 37.465 33.655 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(dnp no)
 		(property "Reference" "#PWR039"
-			(at 47.625 37.465 0)
+			(at 37.465 40.005 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "GND_IN"
-			(at 47.625 34.925 0)
+			(at 37.465 37.465 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 47.625 31.115 0)
+			(at 37.465 33.655 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 47.625 31.115 0)
+			(at 37.465 33.655 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
-			(at 47.625 31.115 0)
+			(at 37.465 33.655 0)
 			(effects
 				(font
@@
 			)
 		)
-		(property "Footprint" "user_lib:430454000"
+		(property "Footprint" "user_lib:430450400"
 			(at 36.195 26.035 0)
 			(effects
@@
 	(symbol
 		(lib_id "power:VAA")
-		(at 27.305 23.495 0)
+		(at 37.465 17.145 0)
 		(unit 1)
 		(exclude_from_sim no)
@@
 		(fields_autoplaced yes)
 		(property "Reference" "#PWR038"
-			(at 27.305 27.305 0)
+			(at 37.465 20.955 0)
 			(effects
 				(font
@@
 		)
 		(property "Value" "VIN"
-			(at 27.305 18.415 0)
+			(at 37.465 12.065 0)
 			(effects
 				(font
@@
 		)
 		(property "Footprint" ""
-			(at 27.305 23.495 0)
+			(at 37.465 17.145 0)
 			(effects
 				(font
@@
 		)
 		(property "Datasheet" ""
-			(at 27.305 23.495 0)
+			(at 37.465 17.145 0)
 			(effects
 				(font
@@
 		)
 		(property "Description" "Power symbol creates a global label with name \"VAA\""
-			(at 27.305 23.495 0)
+			(at 37.465 17.145 0)
 			(effects
 				(font

Commit message: Update PCB concept
Parts:
- added R339, R340, R341, R342: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R_Small
Connections:
- net GND_12V is gone; now on net GND: C41.1, C49.2, C50.2, C51.2, R14.2, U4.16 (-VOUT)
- net 12V0: now also R339.2
- net GND: now also R342.1
- new net: R340.1, R341.2
- new net: R339.1, R340.2
- new net 12V0_SENS: R341.1, R342.2
