File: Hardware/ciam/impeller18/fan.kicad_sch (KiCad schematic)
At the start: 10 parts, among them J16 430450415, U47 HCPL-0600, U64 LDL1117S50R

Commit message: updated schematics
Parts:
- added D18: FYLS-0603BUGC, symbol Device:LED
- added R249: 150, symbol Device:R_Small
- renumbered C25 to C103, C87 to C104, C88 to C105, C89 to C106, J16 to J19, R228 to R246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
Connections:
- net 5V0_FAN: now also R249.1
- net GND_12V: now also D18.1 (K)
- new net: D18.2 (A), R249.2

Commit message: updated schematics
Connections:
- net GND_12V: no longer C103.2, C104.2, C105.2, C106.2, D18.1 (K), J19.4 (Pin_4), U67.1 (GND)
- net 12V0 renamed 12V0_FAN
- new net GND_FAN: C103.2, C104.2, C105.2, C106.2, D18.1 (K), J19.4 (Pin_4), U67.1 (GND)
Other:
- note added: "SMU02M-12"
Changed lines of the file:
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@@
+		)
+	)
+	(text "SMU02M-12"
+		(exclude_from_sim no)
+		(at 45.085 89.535 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
 		)
 	)
@@
 	)
 	(symbol
+		(lib_id "power:GND")
+		(at 140.335 100.33 0)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(property "Reference" "#PWR0214"
+			(at 140.335 106.68 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Value" "GND_FAN"
+			(at 140.335 104.14 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+			)
+		)
+		(property "Footprint" ""
+			(at 140.335 100.33 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" ""
+			(at 140.335 100.33 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
+			(at 140.335 100.33 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(instances
+			(project "impeller18"
+				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/c3c0fd22-6514-4a88-b2de-2515415ad3c7"
+					(reference "#PWR0214")
+					(unit 1)
+				)
+			)
+		)
+	)
+	(symbol
 		(lib_id "power:+12V")
 		(at 118.745 83.82 0)
@@
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/c3c0fd22-6514-4a88-b2de-2515415ad3c7"
 					(reference "#PWR0218")
+					(unit 1)
+				)
+			)
+		)
+	)
+	(symbol
+		(lib_id "power:GND")
+		(at 135.89 58.42 0)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(property "Reference" "#PWR0213"
+			(at 135.89 64.77 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Value" "GND_FAN"
+			(at 135.89 62.23 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+			)
+		)
+		(property "Footprint" ""
+			(at 135.89 58.42 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" ""
+			(at 135.89 58.42 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
+			(at 135.89 58.42 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(instances
+			(project "impeller18"
+				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/c3c0fd22-6514-4a88-b2de-2515415ad3c7"
+					(reference "#PWR0213")
 					(unit 1)
 				)
@@
 			)
 		)
-		(property "Value" "GND_12V"
+		(property "Value" "GND_FAN"
 			(at 69.215 104.14 0)
 			(effects
@@
 			)
 		)
-		(property "Value" "12V0"
+		(property "Value" "12V0_FAN"
 			(at 69.215 79.375 0)
 			(effects
@@
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/c3c0fd22-6514-4a88-b2de-2515415ad3c7"
 					(reference "#PWR0217")
-					(unit 1)
-				)
-			)
-		)
-	)
-	(symbol
-		(lib_id "power:+12V")
-		(at 135.89 49.53 0)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(fields_autoplaced yes)
-		(property "Reference" "#PWR0213"
-			(at 135.89 53.34 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Value" "12V0"
-			(at 135.89 45.085 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-			)
-		)
-		(property "Footprint" ""
-			(at 135.89 49.53 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Datasheet" ""
-			(at 135.89 49.53 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Description" "Power symbol creates a global label with name \"+12V\""
-			(at 135.89 49.53 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(pin "1"
-		)
-		(instances
-			(project "impeller18"
-				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/c3c0fd22-6514-4a88-b2de-2515415ad3c7"
-					(reference "#PWR0213")
-					(unit 1)
-				)
-			)
-		)
-	)
-	(symbol
-		(lib_id "power:GND")
-		(at 135.89 58.42 0)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(property "Reference" "#PWR0214"
-			(at 135.89 64.77 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Value" "GND_12V"
-			(at 135.89 62.23 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-			)
-		)
-		(property "Footprint" ""
-			(at 135.89 58.42 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Datasheet" ""
-			(at 135.89 58.42 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
-			(at 135.89 58.42 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(pin "1"
-		)
-		(instances
-			(project "impeller18"
-				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/c3c0fd22-6514-4a88-b2de-2515415ad3c7"
-					(reference "#PWR0214")
 					(unit 1)
 				)
@@
 	)
 	(symbol
+		(lib_id "power:+12V")
+		(at 135.89 49.53 0)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(property "Reference" "#PWR0234"
+			(at 135.89 53.34 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Value" "12V0_FAN"
+			(at 135.89 45.085 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+			)
+		)
+		(property "Footprint" ""
+			(at 135.89 49.53 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" ""
+			(at 135.89 49.53 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Power symbol creates a global label with name \"+12V\""
+			(at 135.89 49.53 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(instances
+			(project "impeller18"
+				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/c3c0fd22-6514-4a88-b2de-2515415ad3c7"
+					(reference "#PWR0234")
+					(unit 1)
+				)
+			)
+		)
+	)
+	(symbol
 		(lib_id "Device:R_Small")
 		(at 98.425 46.99 180)
@@
 					(unit 1)
 				)
-			)
-		)
-	)
-	(symbol
-		(lib_id "power:GND")
-		(at 140.335 100.33 0)
-		(unit 1)
-		(exclude_from_sim no)
-		(in_bom yes)
-		(on_board yes)
-		(dnp no)
-		(property "Reference" "#PWR0220"
-			(at 140.335 106.68 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Value" "GND_12V"
-			(at 140.335 104.14 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-			)
-		)
-		(property "Footprint" ""
-			(at 140.335 100.33 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Datasheet" ""
-			(at 140.335 100.33 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(property "Description" "Power symbol creates a global label with name \"GND\" , ground"
-			(at 140.335 100.33 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(hide yes)
-			)
-		)
-		(pin "1"
-		)
-		(instances
-			(project "impeller18"
-				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/c3c0fd22-6514-4a88-b2de-2515415ad3c7"
-					(reference "#PWR0220")
-					(unit 1)
-				)

Commit message: updated schematics
Parts:
- removed R249: 150, symbol Device:R_Small
- added C111, C112: 100n, symbol Device:C_Small
- added D25: FYLS-0603BUGC, symbol Device:LED
- added R274: 470, symbol Device:R_Small
- added R275: 360, symbol Device:R_Small
- added U75: SMU02M-12, symbol user_lib:SMU02M-12
- C113: renamed from C103; Ссылка https://www.chipdip.ru/product/grm21br61e475ka12l -> (none); Цена 13 -> (none); Человекопонятное название Конденсатор 4.7мкФ -> (none)
- C114: renamed from C104; Ссылка https://www.chipdip.ru/product/grm21br71h104k -> (none); Цена 13 -> (none); Человекопонятное название Конденсатор 100нФ -> (none)
- C115: renamed from C105; Ссылка https://www.chipdip.ru/product/grm21br61e475ka12l -> (none); Цена 13 -> (none); Человекопонятное название Конденсатор 4.7мкФ -> (none)
- C116: renamed from C106; Ссылка https://www.chipdip.ru/product/grm21br71h104k -> (none); Цена 13 -> (none); Человекопонятное название Конденсатор 100нФ -> (none)
- U74: renamed from U67; Ссылка https://www.chipdip.ru/product/ldl1117s33r-stm -> (none); Цена 33 -> (none); Человекопонятное название LDO-стабилизатор напряжения -> (none)
- renumbered D18 to D26, J19 to J20, R246 to R271, R247 to R272, R248 to R273, U66 to U73
Connections:
- net 12V0_FAN: now also C112.1, R274.2, U75.4 (+Vout)
- net 5V0_FAN: now also R275.2
- net GND_12V: now also C111.2, U75.1 (-Vin)
- net GND_FAN: now also C112.2, D25.1 (K), U75.3 (-Vout)
- net at D26.2 (A): now also R275.1
- new net: D25.2 (A), R274.1
- new net 12V0: C111.1, U75.2 (+Vin)
Other:
- note removed: "SMU02M-12"
- moved on the sheet: C113, C114, C115, C116, D26, J20, R271, R272, R273, U73, U74

Commit message: updated schematics
Parts:
- C111, C112, C114, C116: Мин. кол-во (none) -> 300; Ссылка (none) -> https://www.promelec.ru/product/323633/; Цена (none) -> 2; Человекопонятное название (none) -> Керамический ЧИП-конденсатор 0603 X7R 0.1мкФ
- C113: Мин. кол-во (none) -> 200; Ссылка (none) -> https://www.promelec.ru/product/334556/; Цена (none) -> 1; Человекопонятное название (none) -> Керамический ЧИП-конденсатор 0603 X7R 1мкФ
- C115: Мин. кол-во (none) -> 200; Ссылка (none) -> https://www.promelec.ru/product/315964/; Цена (none) -> 4; Человекопонятное название (none) -> Керамический ЧИП-конденсатор 0603 X5R 4.7мкФ
- D25, D26: footprint (none) -> LED_SMD:LED_0603_1608Metric; Мин. кол-во (none) -> 3; Ссылка (none) -> https://www.promelec.ru/product/324327/; Цена (none) -> 5; Человекопонятное название (none) -> Светодиод smd 1,6х0,8мм/зеленый/568нм/65мкд/прозрачный/130°
- J23: renamed from J20; Мин. кол-во (none) -> 6; Ссылка (none) -> https://www.promelec.ru/product/474679/; Цена (none) -> 87; Человекопонятное название (none) -> Разъем типа провод-плата, 3 мм, 4 контакт(-ов)
- R279: renamed from R271; Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R280: renamed from R272; Мин. кол-во (none) -> 1000; Ссылка (none) -> https://www.promelec.ru/product/344748/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 10кОм
- R281: renamed from R273; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/46446/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 220Ом
- R282: renamed from R274; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/109567/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 470Ом
- R283: renamed from R275; Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/46471/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 360Ом
- U75: renamed from U73; Мин. кол-во (none) -> 1; Ссылка (none) -> https://energoflot.ru/item/HCPL-0600-500E; Цена (none) -> 133; Человекопонятное название (none) -> Быстродействующая оптопара
- U76: renamed from U74; Мин. кол-во (none) -> 14; Ссылка (none) -> https://www.promelec.ru/product/429208/; Цена (none) -> 37; Человекопонятное название (none) -> Линейный стабилизатор с низким падением напряжения положите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
- U77: renamed from U75; Мин. кол-во (none) -> 2; Ссылка (none) -> https://www.promelec.ru/product/371234/; Цена (none) -> 458; Человекопонятное название (none) -> Преобразователь DC/DC, на печатную плату, 2 Вт

Commit message: updatec schematics
Parts:
- added TP33, TP34, TP35, TP36: TestPoint, symbol Connector:TestPoint
Connections:
- net 12V0_FAN: now also TP33.1
- net 5V0_FAN: now also TP35.1
- net GND_FAN: now also TP34.1, TP36.1
