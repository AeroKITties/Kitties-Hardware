File: Hardware/ciam/impeller18/rpi.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: updated schematics
Parts:
- added C68: 10u, symbol Device:C_Small
- added C69: 1u, symbol Device:C_Small
- added C70: 100n, symbol Device:C_Small
- added J4: Raspberry_Pi_2_3, symbol Connector:Raspberry_Pi_2_3
Connections:
- new net: J4.1 (3V3), J4.17 (3V3)
- new net 5V0: C68.2, C69.2, C70.2, J4.2 (5V), J4.4 (5V)
- new net CAN0_RPI_INT: J4.16 (GPIO23)
- new net CAN1_RPI_INT: J4.22 (GPIO25)
- new net GND: C68.1, C69.1, C70.1, J4.14 (GND), J4.20 (GND), J4.25 (GND), J4.30 (GND), J4.34 (GND), J4.39 (GND), J4.6 (GND), J4.9 (GND)
- new net SPI0_RPi_MOSI: J4.19 (MOSI0/GPIO10)
- new net SPI1_RPi_CAN0_CS: J4.24 (~{CE0}/GPIO8)
- new net SPI1_RPi_CAN1_CS: J4.26 (~{CE1}/GPIO7)
- new net SPI1_RPi_MISO: J4.21 (MISO0/GPIO9)
- new net SPI1_RPi_SCK: J4.23 (SCLK0/GPIO11)
- no-connect marks 0 -> 20
Other:
- note added: "ТУТ БУДЕТ uART"

Commit message: updated schematics
Parts:
- added D19, D20: FYLS-3528RGBC, user_lib:LED_RGB_promelec, symbol Device:LED_RGBA
- added R250, R251, R252, R253, R254, R255: 220, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- J5: renamed from J4; value Raspberry_Pi_2_3 -> Raspberry Pi 4
- renumbered C68 to C67, C69 to C68, C70 to C69
Connections:
- new net: D20.1 (RK), R253.1
- new net: D20.3 (BK), R255.1
- new net: D20.4 (GK), R254.1
- new net: D19.1 (RK), R250.1
- new net: D19.3 (BK), R252.1
- new net: D19.4 (GK), R251.1
- new net 3V3: D19.2 (A), D20.2 (A)

Commit message: updated schematics
Parts:
- renumbered C67 to C73, C68 to C74, C69 to C75, D19 to D12, D20 to D13, R250 to R35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
Connections:
- net UART1_STM32_TX: now reaches J5.10 (GPIO15/RXD)
- net UART1_STM32_RX: now reaches J5.8 (GPIO14/TXD)
Other:
- note removed: "ТУТ БУДЕТ uART"
Changed lines of the file:
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@@
 		)
 	)
-	(text "ТУТ БУДЕТ uART"
-		(exclude_from_sim no)
-		(at 160.02 94.615 0)
+	(global_label "UART1_STM32_TX"
+		(shape input)
+		(at 170.18 95.885 180)
+		(fields_autoplaced yes)
 		(effects
 			(font
 				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 151.1688 95.885 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
 			)
 		)
@@
 		)
 	)
+	(global_label "UART1_STM32_RX"
+		(shape input)
+		(at 170.18 93.345 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 150.8664 93.345 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
+		)
+	)
 	(global_label "SPI0_RPi_MOSI"
 		(shape input)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "#PWR086"
+		(property "Reference" "#PWR0100"
 			(at 185.42 65.405 0)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "#PWR086")
+					(reference "#PWR0100")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "#PWR088"
+		(property "Reference" "#PWR0104"
 			(at 190.5 159.385 0)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "#PWR088")
+					(reference "#PWR0104")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "D20"
+		(property "Reference" "D13"
 			(at 273.685 137.16 0)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "D20")
+					(reference "D13")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "R254"
+		(property "Reference" "R39"
 			(at 282.575 123.825 90)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "R254")
+					(reference "R39")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "C68"
+		(property "Reference" "C74"
 			(at 174.625 68.58 90)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "C68")
+					(reference "C74")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "C67"
+		(property "Reference" "C73"
 			(at 176.53 63.5 90)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "C67")
+					(reference "C73")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "D19"
+		(property "Reference" "D12"
 			(at 273.685 109.855 0)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "D19")
+					(reference "D12")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "R255"
+		(property "Reference" "R40"
 			(at 282.575 128.905 90)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "R255")
+					(reference "R40")
 					(unit 1)
 				)
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "#PWR0221"
+		(property "Reference" "#PWR0102"
 			(at 265.43 99.695 0)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "#PWR0221")
+					(reference "#PWR0102")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "R251"
+		(property "Reference" "R36"
 			(at 282.575 96.52 90)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "R251")
+					(reference "R36")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "R252"
+		(property "Reference" "R37"
 			(at 282.575 101.6 90)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "R252")
+					(reference "R37")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "C69"
+		(property "Reference" "C75"
 			(at 176.53 74.93 90)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "C69")
+					(reference "C75")
 					(unit 1)
 				)
@@
 		(dnp no)
 		(fields_autoplaced yes)
-		(property "Reference" "#PWR0222"
+		(property "Reference" "#PWR0103"
 			(at 265.43 127 0)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "#PWR0222")
+					(reference "#PWR0103")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "#PWR087"
+		(property "Reference" "#PWR0101"
 			(at 170.815 85.09 0)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "#PWR087")
+					(reference "#PWR0101")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "R250"
+		(property "Reference" "R35"
 			(at 282.575 91.44 90)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "R250")
+					(reference "R35")
 					(unit 1)
 				)
@@
 		(on_board yes)
 		(dnp no)
-		(property "Reference" "R253"
+		(property "Reference" "R38"
 			(at 282.575 118.745 90)
 			(effects
@@
 			(project "impeller18"
 				(path "/4ccab03b-4b1c-4c61-9fa8-19853ef32b4d/36ec6b10-e9ff-4e61-94d3-a2b8a8777c75"
-					(reference "R253")
-					(unit 1)
-				)
+					(reference "R38")
+					(unit 1)
+				)

Commit message: updated schematics
Parts:
- C73: Мин. кол-во (none) -> 200; Ссылка (none) -> https://www.promelec.ru/product/430347/; Цена (none) -> 4; Человекопонятное название (none) -> Керамический ЧИП-конденсатор 0603 X5R 10мкФ
- C74: Мин. кол-во (none) -> 200; Ссылка (none) -> https://www.promelec.ru/product/334556/; Цена (none) -> 1; Человекопонятное название (none) -> Керамический ЧИП-конденсатор 0603 X7R 1мкФ
- C75: Мин. кол-во (none) -> 300; Ссылка (none) -> https://www.promelec.ru/product/323633/; Цена (none) -> 2; Человекопонятное название (none) -> Керамический ЧИП-конденсатор 0603 X7R 0.1мкФ
- D12, D13: footprint user_lib:LED_RGB_promelec -> (none); Мин. кол-во (none) -> 2; Ссылка (none) -> https://www.promelec.ru/product/337147/; Цена (none) -> 8; Человекопонятное название (none) -> Светодиод smd 3,5х2,8мм/красный/625нм/200мкд - зеленый/520н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
- J7: renamed from J5; Мин. кол-во (none) -> 1; Ссылка (none) -> https://www.chipdip.ru/product/raspberry-pi-4-model-b-4gb; Цена (none) -> 17000; Человекопонятное название (none) -> Одноплатный компьютер
- R35, R36, R37, R38, R39, R40: footprint Resistor_SMD:R_0603_1608Metric -> (none); Мин. кол-во (none) -> 100; Ссылка (none) -> https://www.promelec.ru/product/46446/; Цена (none) -> 1; Человекопонятное название (none) -> Толстопленочный ЧИП-резистор 0603 220Ом

Commit message: updatec schematics
Connections:
- net UART1_STM32_RX renamed UARTX_STM32_RX
- net UART1_STM32_TX renamed UARTX_STM32_TX
Changed lines of the file:
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@@
 		)
 	)
-	(global_label "UART1_STM32_TX"
+	(global_label "UARTX_STM32_TX"
 		(shape input)
 		(at 170.18 95.885 180)
@@
 				)
 				(justify left)
-				(hide yes)
-			)
-		)
-	)
-	(global_label "UART1_STM32_RX"
-		(shape input)
-		(at 170.18 93.345 180)
-		(fields_autoplaced yes)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify right)
-		)
-		(property "Intersheetrefs" "${INTERSHEET_REFS}"
-			(at 150.8664 93.345 0)
-			(effects
-				(font
-					(size 1.27 1.27)
-				)
-				(justify right)
 				(hide yes)
 			)
@@
 				(hide yes)
 			)
+		)
+	)
+	(global_label "UARTX_STM32_RX"
+		(shape input)
+		(at 170.18 93.345 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right)
+		)
+		(property "Intersheetrefs" "${INTERSHEET_REFS}"
+			(at 150.8664 93.345 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify right)
+				(hide yes)
+			)
