File: Hardware/ciam/impeller18/indicators.kicad_sch (KiCad schematic)
At the start: 52 parts, among them J15 430450600, J16 430451800, J17 430451800, U35 G3VM61VY2, U36 G3VM61VY2, U37 G3VM61VY2, U38 G3VM61VY2, U39 G3VM61VY2, U40 G3VM61VY2, U41 G3VM61VY2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

Commit message: fixed led indicators
Parts:
- added Q40, Q41, Q42, Q43, Q44, Q45, Q46, Q47, Q48, Q49, Q50, Q51, Q52, Q53, Q54, Q55, Q56, Q57, Q58, Q59, Q60: BSS138, Package_TO_SOT_SMD:SOT-23, symbol Transistor_FET:BSS138
- added R318, R319, R320, R321, R322, R323, R324, R325, R326, R327, R328, R329, R330, R331, R332, R333, R334, R335, R336, R337, R338: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R_Small
Connections:
- net 3V3: now also R318.1, R319.1, R320.1, R321.1, R322.1, R323.1, R324.1, R325.1, R326.1, R327.1, R328.1, R329.1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
- net LED10_EXT: now also Q49.1 (G); no longer U36.2
- net LED11_EXT: now also Q50.1 (G); no longer U39.2
- net LED12_EXT: now also Q51.1 (G); no longer U42.2
- net LED13_EXT: now also Q52.1 (G); no longer U45.2
- net LED14_EXT: now also Q53.1 (G); no longer U47.2
- net LED15_EXT: now also Q54.1 (G); no longer U49.2
- net LED16_EXT: now also Q55.1 (G); no longer U51.2
- net LED17_EXT: now also Q56.1 (G); no longer U53.2
- net LED18_EXT: now also Q57.1 (G); no longer U55.2
- net LED19_EXT: now also Q58.1 (G); no longer U37.2
- net LED1_EXT: now also Q40.1 (G); no longer U35.2
- net LED20_EXT: now also Q59.1 (G); no longer U40.2
- net LED21_EXT: now also Q60.1 (G); no longer U43.2
- net LED2_EXT: now also Q41.1 (G); no longer U38.2
- net LED3_EXT: now also Q42.1 (G); no longer U41.2
- net LED4_EXT: now also Q43.1 (G); no longer U44.2
- net LED5_EXT: now also Q44.1 (G); no longer U46.2
- net LED6_EXT: now also Q45.1 (G); no longer U48.2
- net LED7_EXT: now also Q46.1 (G); no longer U50.2
- net LED8_EXT: now also Q47.1 (G); no longer U52.2
- net LED9_EXT: now also Q48.1 (G); no longer U54.2
- new net: Q54.3 (D), R332.2, U49.2
- new net: Q58.3 (D), R336.2, U37.2
- new net: Q52.3 (D), R330.2, U45.2
- new net: Q57.3 (D), R335.2, U55.2
- new net: Q48.3 (D), R326.2, U54.2
- new net: Q59.3 (D), R337.2, U40.2
- new net: Q56.3 (D), R334.2, U53.2
- new net: Q51.3 (D), R329.2, U42.2
- new net: Q44.3 (D), R322.2, U46.2
- new net: Q43.3 (D), R321.2, U44.2
- new net: Q55.3 (D), R333.2, U51.2
- new net: Q45.3 (D), R323.2, U48.2
- new net: Q40.3 (D), R318.2, U35.2
- new net: Q53.3 (D), R331.2, U47.2
- new net: Q41.3 (D), R319.2, U38.2
- new net: Q60.3 (D), R338.2, U43.2
- new net: Q42.3 (D), R320.2, U41.2
- new net: Q47.3 (D), R325.2, U52.2
- new net: Q49.3 (D), R327.2, U36.2
- new net: Q46.3 (D), R324.2, U50.2
- new net: Q50.3 (D), R328.2, U39.2
- new net GND: Q40.2 (S), Q41.2 (S), Q42.2 (S), Q43.2 (S), Q44.2 (S), Q45.2 (S), Q46.2 (S), Q47.2 (S), Q48.2 (S), Q49.2 (S), Q50.2 (S), Q51.2 (S)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
Other:
- moved on the sheet: R168, R169, R170, R171, R172, R173, R174, R175, R176, R177, R178, R179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

Commit message: Updated 3D models
Parts:
- renumbered C88 to C103, C89 to C104, J15 to J23, J16 to J24, J17 to J25, Q40 to Q37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

Commit message: updated bom
Parts:
- removed C103: 470u, Capacitor_THT:CP_Radial_D12.5mm_P5.00mm, symbol Device:C_Polarized_Small
- added C105, C106: 47u, Capacitor_THT:CP_Radial_D10.0mm_P5.00mm, symbol Device:C_Polarized_Small
- renumbered C104 to C107
Connections:
- net 12V0: now also C105.1
- net 12V0_LED: now also C106.1
- net GND_12V: now also C105.2
- net GND_LED: now also C106.2
