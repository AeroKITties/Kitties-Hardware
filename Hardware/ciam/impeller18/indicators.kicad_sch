File: Hardware/ciam/impeller18/indicators.kicad_sch (KiCad schematic)
At the start: 95 parts, among them J23 430450600, J24 430451800, J25 430451800, Q37 BSS138, Q38 BSS138, Q39 BSS138, Q40 BSS138, Q41 BSS138, Q42 BSS138, Q43 BSS138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

Commit message: Update PCB concept
Connections:
- net GND_12V is gone; now on net GND: C105.2, U55.2 (-VIN), U55.3 (-VIN)
- net 12V0_LED: now also J23.1 (Pin_1), J23.3 (Pin_3), J24.1 (Pin_1), J24.3 (Pin_3), J24.5 (Pin_5), J24.7 (Pin_7), J24.9 (Pin_9), J25.1 (Pin_1), J25.3 (Pin_3), J25.5 (Pin_5), J25.7 (Pin_7), J25.9 (Pin_9); no longer J23.4 (Pin_4), J23.6 (Pin_6), J24.10 (Pin_10), J24.12 (Pin_12), J24.14 (Pin_14), J24.16 (Pin_16), J24.18 (Pin_18), J25.10 (Pin_10), J25.12 (Pin_12), J25.14 (Pin_14), J25.16 (Pin_16), J25.18 (Pin_18)
- net LED10_EXT_12V: now also J25.10 (Pin_10); no longer J25.1 (Pin_1)
- net LED11_EXT_12V: now also J25.11 (Pin_11); no longer J25.3 (Pin_3)
- net LED12_EXT_12V: now also J25.12 (Pin_12); no longer J25.5 (Pin_5)
- net LED13_EXT_12V: now also J25.13 (Pin_13); no longer J25.7 (Pin_7)
- net LED14_EXT_12V: now also J25.14 (Pin_14); no longer J25.9 (Pin_9)
- net LED15_EXT_12V: now also J25.15 (Pin_15); no longer J25.11 (Pin_11)
- net LED16_EXT_12V: now also J25.16 (Pin_16); no longer J25.13 (Pin_13)
- net LED17_EXT_12V: now also J25.17 (Pin_17); no longer J25.15 (Pin_15)
- net LED18_EXT_12V: now also J25.18 (Pin_18); no longer J25.17 (Pin_17)
- net LED19_EXT_12V: now also J23.4 (Pin_4); no longer J23.1 (Pin_1)
- net LED1_EXT_12V: now also J24.10 (Pin_10); no longer J24.1 (Pin_1)
- net LED20_EXT_12V: now also J23.5 (Pin_5); no longer J23.3 (Pin_3)
- net LED21_EXT_12V: now also J23.6 (Pin_6); no longer J23.5 (Pin_5)
- net LED2_EXT_12V: now also J24.11 (Pin_11); no longer J24.3 (Pin_3)
- net LED3_EXT_12V: now also J24.12 (Pin_12); no longer J24.5 (Pin_5)
- net LED4_EXT_12V: now also J24.13 (Pin_13); no longer J24.7 (Pin_7)
- net LED5_EXT_12V: now also J24.14 (Pin_14); no longer J24.9 (Pin_9)
- net LED6_EXT_12V: now also J24.15 (Pin_15); no longer J24.11 (Pin_11)
- net LED7_EXT_12V: now also J24.16 (Pin_16); no longer J24.13 (Pin_13)
- net LED8_EXT_12V: now also J24.17 (Pin_17); no longer J24.15 (Pin_15)
- net LED9_EXT_12V: now also J24.18 (Pin_18); no longer J24.17 (Pin_17)
Other:
- moved on the sheet: J25
