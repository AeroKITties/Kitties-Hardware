# Repository AeroKITties/Kitties-Hardware (continued)

## KiCad design Hardware/Royal Penguin/2.0/2.0.kicad_pcb

Board: 4 copper layers, 66.0 x 47.0 mm, 169 parts (51 on the bottom side), 136 nets.

Parts:
C1: 4u7; C_0603_1608Metric
C2, C3, C4, C5, C6, C7, C8, C9, C11, C13, C18, C19, C22, C23, C24, C25, C27, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C43: 100n; C_0603_1608Metric
C10, C12: 1u; C_0603_1608Metric
C14, C15, C28: 2u2; C_0603_1608Metric
C16, C17: 8p; C_0603_1608Metric
C20: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21: 4u7; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C26: 10n; C_0603_1608Metric
C41, C42: 47u; C_1206_3216Metric
D1, D2, D3: LED_MCU; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D5, D7: PMEG2020EH; D_SOD-123F
D8, D9, D10, D11: LED_POWER; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
F1, F2: MF-MSMF260-2; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
F3: MF-NSMF050-2; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4: MH_M3_Corner; MountingHole_3.2mm_M3_Pad_Via
J1: Conn_Power_brick_01x06; Molex_PicoBlade_53047-0610_1x06_P1.25mm_Vertical
J2, J5: Conn_01x03_Video; Molex_PicoBlade_53047-0310_1x03_P1.25mm_Vertical
J3: USB_B_Micro; U-F-M5DD-W-2-SUS
J4: Micro_SD_Card_Con; TF01A
J6, J7, J8: Conn_01x12_servo; PinHeader_1x12_P2.54mm_Vertical
J9, J12: Conn_01x04_I2C; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
J10, J11: Conn_01x06_UART; Molex_PicoBlade_53047-0610_1x06_P1.25mm_Vertical
J13, J14, J15: Conn_01x04_UART; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
J16: Conn_02x05_SWD; PinHeader_2x05_P1.27mm_Vertical
J17: Conn_01x07_SPI; Molex_PicoBlade_53047-0710_1x07_P1.25mm_Vertical
J18, J19: Conn_01x04_ADC; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
J20: Conn_01x04_CAN; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
JP1, JP2: Jumper_power; PinHeader_1x02_P2.54mm_Vertical
Q1: BSS138; SOT-23
R1, R9, R10, R35, R36, R37, R38, R39, R40, R41, R43, R45, R46: 10k; R_0603_1608Metric
R2: 0; R_0603_1608Metric
R3, R4, R5, R13, R14, R15, R16: 220; R_0603_1608Metric
R7, R8: 4k7; R_0603_1608Metric
R11, R12: 1M; R_0603_1608Metric
R17, R18, R19, R20, R21, R22: 100k; R_0603_1608Metric
R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34: 22; R_0603_1608Metric
R42: 120; R_0603_1608Metric
R44, R47: 75; R_0603_1608Metric
SW1: SW_RESET; tactile switch 6x6mm smd
SW2: SW_BOOT0; MSS-12D16
TP1, TP2, TP3, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14: TestPointSignal; TestPoint_Pad_D1.0mm
TP4, TP25: TestPointCrystal; TestPoint_Pad_D1.0mm
TP15, TP16, TP17, TP18, TP19, TP26: TestPointPower; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP20, TP21, TP22, TP23: TestPointGND; TestPoint_THTPad_1.0x1.0mm_Drill0.5mm
TP24: BridgeGND; TestPoint_Bridge_Pitch5.08mm_Drill0.7mm
U1: STM32F427VGTx; LQFP-100_14x14mm_P0.5mm
U2: LDL1117S33R; SOT-223-3_TabPin2
U3: USBLC6-2SC6; SOT-23-6
U4: BMI088; LGA-16_3x4.5x0.95mm
U5: ICM-42688-P; LGA-14_2.5x3x0.91mm
U6: MPU-9250; InvenSense_QFN-24_3x3mm_P0.4mm
U7: MS5611-01BA; LGA-8_3x5mm_P1.25mm_handsolder
U8: BMP388; LGA-10_2x2x0.75mm
U9: W25Q32FVSSIG; SOIC-8_5.275x5.275mm_P1.27mm
U10: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm
U11: MAX7456; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.85x5.4mm
Y1: 16M; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 27M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/Connections/usb_conn_d+: J3.3 (D+), U3.6 (I/O1)
/Connections/usb_conn_d-: J3.2 (D-), U3.4 (I/O2)
/OSD/MAX7456_MISO_5V: Q1.3 (D), R46.2, U11.11 (SDOUT)
ADC2_IN10: R38.2, R39.1, U1.15 (PC0)
ADC2_IN11: R35.2, R36.1, U1.16 (PC1)
ADC2_IN12: R40.1, U1.17 (PC2)
ADC2_IN13: R37.1, U1.18 (PC3)
BATT_CURRENT_SENS: R9.2, TP14.1, U1.33 (PC4)
BATT_VOLT_SENS: R10.2, TP13.1, U1.34 (PC5)
BMI088_INT1: U1.60 (PD13), U4.16 (INT1)
BMI088_INT2: U1.61 (PD14), U4.1 (INT2)
BMI088_INT3: U1.59 (PD12), U4.12 (INT3)
BMI088_INT4: U1.57 (PD10), U4.13 (INT4)
BOOT0: R1.1, U1.94 (BOOT0)
CAN1_RX: U1.81 (PD0), U10.4 (RXD)
CAN1_TX: U1.82 (PD1), U10.1 (TXD)
CAN_HIGH: J20.2, R42.1, U10.7 (CANH)
CAN_LOW: J20.3, R42.2, U10.6 (CANL)
CS_BMI088_A: U1.58 (PD11), U4.14 (CSB1)
CS_BMI088_G: U1.62 (PD15), U4.5 (CSB2)
CS_BMP388: U1.55 (PD8), U8.6 (CSB)
CS_EXT0: J17.5, U1.2 (PE3)
CS_EXT1: J17.6, U1.3 (PE4)
CS_FLASH: U1.8 (PC14), U9.1 (~CS)
CS_ICM42688P: U1.37 (PB2), U5.12 (AP_CS)
CS_MPU9250: U1.29 (PA4), U6.22 (~CS)
CS_MS5611: U1.25 (PA2), U7.4 (CSB), U7.5 (CSB)
CS_OSD: U1.7 (PC13), U11.8 (CS)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, C33.1, C34.1, C35.1, C36.2, C37.2, C38.2, C39.2, C40.2, D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), J1.5, J1.6, J2.2, J3.5 (GND), J3.6 (Shield), J4.6 (VSS), J4.10 (SHIELD), J5.2, J7.1, J7.2, J7.3, J7.4, J7.5, J7.6, J7.7, J7.8, J7.9, J7.10, J7.11, J7.12, J9.4, J10.6, J11.6, J12.4, J13.4, J14.4, J15.4, J16.3, J16.5, J16.9, J17.7, J18.4, J19.4, J20.4, R11.2, R12.2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
HSE_IN: R2.2, U1.12 (PH0)
HSE_OUT: C17.1, U1.13 (PH1), Y1.3
I2C2_SCL: J9.2, J12.2, R7.1, TP11.1, U1.47 (PB10)
I2C2_SDA: J9.3, J12.3, R8.1, TP12.1, U1.48 (PB11)
ICM42688P_INT1: U1.38 (PE7), U5.4 (INT1/INT)
ICM42688P_INT2: U1.39 (PE8), U5.9 (INT2/FSYNC/CLKIN)
INT_BMP388: U1.56 (PD9), U8.7 (INT)
LED_MCU_0: D1.1 (K), U1.41 (PE10)
LED_MCU_1: D2.1 (K), U1.43 (PE12)
LED_MCU_2: D3.1 (K), U1.46 (PE15)
MPU9250_INT: U1.26 (PA3), U6.12 (INT)
NRST: C13.1, J16.10, SW1.1, U1.14 (NRST)
unnamed: C16.1, R2.1, TP4.1, Y1.1
unnamed: C41.2, C42.2, R44.1
unnamed: D1.2 (A), R3.1
unnamed: D2.2 (A), R4.1
unnamed: D3.2 (A), R5.1
unnamed: D5.2 (A), F1.2
unnamed: D5.1 (K), D7.1 (K), F2.1, F3.1
unnamed: D8.2 (A), R13.2
unnamed: D9.2 (A), R14.2
unnamed: D10.2 (A), R15.2
unnamed: D11.2 (A), R16.2
unnamed: C19.1, J1.3, R9.1, R12.1
unnamed: C18.1, J1.4, R10.1, R11.1
unnamed: J6.1, R23.2
unnamed: J6.2, R24.2
unnamed: J6.3, R25.2
unnamed: J6.4, R26.2
unnamed: J6.5, R27.2
unnamed: J6.6, R28.2
unnamed: J6.7, R29.2
unnamed: J6.8, R30.2
unnamed: J6.9, R31.2
unnamed: J6.10, R32.2
unnamed: J6.11, R33.2
unnamed: J6.12, R34.2
unnamed: J18.2, R36.2
unnamed: J18.3, R39.2
unnamed: J19.2, R37.2
unnamed: J19.3, R40.2
unnamed: F2.2, JP1.1 (A)
unnamed: F3.2, JP2.1 (A)
unnamed: R1.2, SW2.2 (B)
unnamed: C31.1, U6.10 (REGOUT)
unnamed: R41.1, U9.3 (IO2)
unnamed: R43.1, U9.7 (IO3)
unnamed: TP25.1, U11.5 (CLKIN), Y2.3
unnamed: C41.1, U11.25 (SAG)
unnamed: C43.1, U11.22 (VIN)
unnamed: C42.1, U11.26 (VOUT)
unnamed: U11.6 (XFB), Y2.1
SDIO_CLK: J4.5 (CLK), U1.80 (PC12)
SDIO_CMD: J4.3 (CMD), R20.2, U1.83 (PD2)
SDIO_DAT0: J4.7 (DAT0), R19.2, U1.65 (PC8)
SDIO_DAT1: J4.8 (DAT1), R18.2, U1.66 (PC9)
SDIO_DAT2: J4.1 (DAT2), R22.2, U1.78 (PC10)
SDIO_DAT3: J4.2 (DAT3/CD), R21.2, U1.79 (PC11)
SD_CD: J4.9 (DET), R17.2, U1.67 (PA8)
SPI1_MISO: TP2.1, U1.31 (PA6), U5.1 (AP_SDO/AP_AD0), U6.9 (AD0/MISO), U7.6 (SDO)
SPI1_MOSI: TP3.1, U1.32 (PA7), U5.14 (AP_SDI/AP_SDA), U6.24 (SDA/MOSI), U7.7 (SDI/SDA)
SPI1_SCK: TP1.1, U1.30 (PA5), U5.13 (AP_SCL/AP_SCLK), U6.23 (SCL/SCLK), U7.8 (SCLK)
SPI2_MISO: TP6.1, U1.53 (PB14), U4.10 (SDO2), U4.15 (SDO1), U8.5 (SDO)
SPI2_MOSI: TP7.1, U1.54 (PB15), U4.9 (SDA/SDI), U8.4 (SDI)
SPI2_SCK: TP5.1, U1.52 (PB13), U4.8 (SCL/SCK), U8.2 (SCK)
SPI4_MISO: J17.3, Q1.2 (S), R45.2, TP9.1, U1.4 (PE5), U9.2 (DO(IO1))
SPI4_MOSI: J17.4, TP10.1, U1.5 (PE6), U9.5 (DI(IO0)), U11.9 (SDIN)
SPI4_SCK: J17.2, TP8.1, U1.1 (PE2), U9.6 (CLK), U11.10 (SCLK)
SYS_SWCLK: J16.4, U1.76 (PA14)
SYS_SWDIO: J16.2, U1.72 (PA13)
SYS_SWO: J16.6, U1.89 (PB3)
TIM1_CH1: R32.1, U1.40 (PE9)
TIM1_CH2: R31.1, U1.42 (PE11)
TIM1_CH3: R30.1, U1.44 (PE13)
TIM1_CH4: R29.1, U1.45 (PE14)
TIM3_CH1: R23.1, U1.90 (PB4)
TIM3_CH2: R24.1, U1.91 (PB5)
TIM3_CH3: R34.1, U1.35 (PB0)
TIM3_CH4: R33.1, U1.36 (PB1)
TIM4_CH1: R25.1, U1.92 (PB6)
TIM4_CH2: R26.1, U1.93 (PB7)
TIM4_CH3: R27.1, U1.95 (PB8)
TIM4_CH4: R28.1, U1.96 (PB9)
UART4_RX: J13.3, U1.24 (PA1)
UART4_TX: J13.2, U1.23 (PA0)
UART8_RX: J15.3, U1.97 (PE0)
UART8_TX: J15.2, U1.98 (PE1)
USART1_RX: J14.3, U1.69 (PA10)
USART1_TX: J14.2, U1.68 (PA9)
USART2_CTS: J10.4, U1.84 (PD3)
USART2_RTS: J10.5, U1.85 (PD4)
USART2_RX: J10.3, U1.87 (PD6)
USART2_TX: J10.2, U1.86 (PD5)
USART6_RX: J11.3, U1.64 (PC7)
USART6_TX: J11.2, U1.63 (PC6)
USB_D+: U1.71 (PA12), U3.1 (I/O1)
USB_D-: U1.70 (PA11), U3.3 (I/O2)
VCAP_1: C14.1, U1.49 (VCAP_1)
VCAP_2: C15.1, U1.73 (VCAP_2)
VDD_3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C21.1, C23.2, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C32.2, C33.2, C34.2, C35.2, C37.1, J4.4 (VDD), J16.1, Q1.1 (G), R3.2, R4.2, R5.2, R7.2, R8.2, R13.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R41.2, R43.2, R45.1, SW2.1 (A), TP19.1, U1.6 (VBAT), U1.11 (VDD), U1.19 (VDD), U1.21 (VREF+), U1.22 (VDDA), U1.28 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U2.2 (VO), U4.3 (VDD), U4.11 (VDDIO), U5.5 (VDDIO), U5.8 (VDD), U6.1 (RESV_VDDIO), U6.8 (VDDIO), U6.13 (VDD), U7.1 (VDD), U8.1 (VDDIO), U8.10 (VDD), U9.8 (VCC), U10.5 (VIO)
VDD_5V_BRICK: F1.1, J1.1, J1.2, TP15.1
VDD_5V_LDO: C20.1, JP2.2 (B), R16.1, TP17.1, U2.3 (VI)
VDD_5V_PERIPH: C36.1, C38.1, C39.1, C40.1, J2.1, J5.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J17.1, J18.1, J19.1, J20.1, JP1.2 (B), R14.1, R46.1, TP16.1, U10.3 (VCC), U11.3 (DVDD), U11.19 (RESET), U11.21 (AVDD), U11.24 (PVDD)
VDD_5V_SERVO: J8.1, J8.2, J8.3, J8.4, J8.5, J8.6, J8.7, J8.8, J8.9, J8.10, J8.11, J8.12, R15.1, TP26.1
VDD_5V_VBUS: C22.1, D7.2 (A), J3.1 (VBUS), TP18.1, U3.5 (VBUS)
VIDEO_IN: C43.2, J5.3, R47.2
VIDEO_OUT: J2.3, R44.2

## KiCad design Hardware/ciam/impeller/impeller/impeller.kicad_pcb

Board: 4 copper layers, 147.4 x 88.4 mm, 260 parts (0 on the bottom side), 194 nets.

Parts:
BT1: KLS5-CR2032-01
C1, C2, C4, C7, C8, C9, C10, C11, C12, C15, C56, C63: 100n; C_0603_1608Metric
C3, C5: 1u; C_0603_1608Metric
C6: 4u7; C_0603_1608Metric
C13, C14, C16, C17: 15p; C_0603_1608Metric
C18, C19: 2u2; C_0603_1608Metric
C20, C22, C25, C44, C46, C48, C55, C58, C61: 4u7; C_0805_2012Metric
C21, C24: 47u; CP_Elec_6.3x5.4
C23, C26, C28, C30, C35, C38, C39, C42, C49, C50, C51, C52, C53, C57, C60, C62: 100n; C_0805_2012Metric
C27, C29, C31, C32: 1u; C_0805_2012Metric
C33, C34: 4n7; C_0805_2012Metric
C36, C37, C40, C41, C43, C45, C47, C54, C59: 10u; C_0805_2012Metric
D1, D2: PESD1CAN; SOT-23
D3: ss24; SS24
D4, D5: FYLS-1206SRC; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
H1, H2: MH_M3_Corner; MountingHole_3.2mm_M3_Pad_Via_5mm
J1: PLS-3; PinHeader_1x03_P2.54mm_Vertical
J2: Conn_02x05_SWD; PinHeader_2x05_P1.27mm_Vertical
J3: USB_B_Micro; U-F-M5DD-W-2-SUS
J4: Micro_SD_Card_Con; TF01A
J5: PicoBlade_1x2P; Molex_PicoBlade_53047-0210_1x02_P1.25mm_Vertical
J6, J7, J16, J17: Micro-Fit_2x2P; Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal
J8, J9, J10, J11, J12: Micro-Fit_2x5P; Molex_Micro-Fit_3.0_43045-1000_2x05_P3.00mm_Horizontal
J13: Micro-Fit_2x12P; Molex_Micro-Fit_3.0_43045-2400_2x12_P3.00mm_Horizontal
J14: PLS-5; PinHeader_1x05_P2.54mm_Vertical
JP1: PLS-2; PinHeader_1x02_P2.54mm_Vertical
L1, L2: B82789C0513H002
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12: BSS138; SOT-23
R1, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R31, R32, R35, R36, R39, R40, R43, R44, R47, R48, R51, R53, R55, R57, R59, R61, R62, R64, R65, R67, R68, R70, R71, R73, R74, R76, R77, R79, R80, R82, R83, R85, R86, R88, R89, R91, R92, R94, R95: 10k; R_0805_2012Metric
R2: 0; R_0603_1608Metric
R3, R4, R5, R6: 60; R_0603_1608Metric
R7, R8: 0; R_0805_2012Metric
R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R93, R96: 220; R_0603_1608Metric
R33, R34, R37, R38, R41, R42, R45, R46, R49, R50, R52, R54, R56, R58, R60: 360; R_0603_1608Metric
R63, R66, R69, R72, R75, R78, R81, R84, R87, R90: 330; R_0603_1608Metric
R97: 150; R_0603_1608Metric
R98: 65; R_0603_1608Metric
R99, R100, R101, R102, R103, R104: 100k; R_0603_1608Metric
R105, R107: 1k; R_0603_1608Metric
R106, R108: 2k; R_0603_1608Metric
SW1: KLS7-TS6601-11-180; SW_PUSH_6mm_H4.3mm
SW2, SW3: DS1040-06RN; SW_DIP_SPSTx06_Slide_9.78x17.42mm_W7.62mm_P2.54mm
U1: STM32F405VGT6; LQFP-100_14x14mm_P0.5mm
U2, U44: LDL1117S33R; SOT-223-3_TabPin2
U3: TEL 5-1211
U4, U5: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm
U6, U7, U28, U29, U35, U41, U45: B0505MT-1WR4
U8, U9, U10, U11, U12, U13, U14, U15, U16, U17: G3VM61D1
U18, U19, U20, U21, U22, U23, U24, U25, U26, U27, U30, U31, U32, U33, U34: TLP291; SOIC-4_4.55x2.6mm_P1.27mm
U36, U37, U38, U39, U40, U43: HCPL-0630; SOIC-8_3.9x4.9mm_P1.27mm
U42: USBLC6-2SC6; SOT-23-6
Y1: KSE-7K32768KDY2400A3
Y2: KSE-7U08000MAB143ZA3

Connections:
/CAN/CAN1+: D2.2, J7.2, L2.3, R6.1
/CAN/CAN1-: D2.1, J7.1, L2.2, R4.1
/CAN/CAN1_+: L2.4, U5.7 (CANH)
/CAN/CAN1_-: L2.1, U5.6 (CANL)
/CAN/CAN2+: D1.2, J6.2, L1.3, R5.1
/CAN/CAN2-: D1.1, J6.1, L1.2, R3.1
/CAN/CAN2_+: L1.4, U4.7 (CANH)
/CAN/CAN2_-: L1.1, U4.6 (CANL)
/General connectors/usb_conn_d+: J3.3 (D+), U42.6 (I/O1)
/General connectors/usb_conn_d-: J3.2 (D-), U42.4 (I/O2)
BOOT0: R1.2, U1.94 (BOOT0)
CAN1_A0: R14.2, SW2.1, U1.63 (PC6)
CAN1_A1: R13.2, SW2.2, U1.64 (PC7)
CAN1_A2: R12.2, SW2.3, U1.67 (PA8)
CAN1_A3: R11.2, SW2.4, U1.68 (PA9)
CAN1_A4: R10.2, SW2.5, U1.69 (PA10)
CAN1_A5: R9.2, SW2.6, U1.77 (PA15)
CAN1_RX: U1.81 (PD0), U5.2 (RXD)
CAN1_TX: U1.82 (PD1), U5.3 (TXD)
CAN2_A0: R20.2, SW3.1, U1.85 (PD4)
CAN2_A1: R19.2, SW3.2, U1.86 (PD5)
CAN2_A2: R18.2, SW3.3, U1.87 (PD6)
CAN2_A3: R17.2, SW3.4, U1.88 (PD7)
CAN2_A4: R16.2, SW3.5, U1.90 (PB4)
CAN2_A5: R15.2, SW3.6, U1.93 (PB7)
CAN2_RX: U1.91 (PB5), U4.2 (RXD)
CAN2_TX: U1.92 (PB6), U4.3 (TXD)
Encoder1_A: Q1.2 (S), R62.2
Encoder1_B: Q2.2 (S), R65.2
Encoder2_A: Q3.2 (S), R68.2
Encoder2_B: Q4.2 (S), R71.2
Encoder3_A: Q5.2 (S), R74.2
Encoder3_B: Q6.2 (S), R77.2
Encoder4_A: Q7.2 (S), R80.2
Encoder4_B: Q8.2 (S), R83.2
Encoder5_A: Q9.2 (S), R86.2
Encoder5_B: Q10.2 (S), R89.2
GND: BT1.2 (-), C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.2, C16.1, C17.1, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C37.2, C38.2, C41.2, C42.2, C44.2, C46.2, C48.2, C49.1, C50.1, C51.1, C52.1, C53.1, C55.2, C56.2, C58.2, C63.1, J1.3, J2.3, J2.5, J2.9, J3.5 (GND), J3.6 (Shield), J4.6 (VSS), J4.10 (SHIELD), J14.2, R97.2, R98.2, R106.1, R108.1, SW1.2, SW2.7, SW2.8, SW2.9, SW2.10, SW2.11, SW2.12, SW3.7, SW3.8, SW3.9, SW3.10, SW3.11, SW3.12, U1.10 (VSS), U1.20 (VSSA), U1.27 (VSS), U1.74 (VSS), U1.99 (VSS), U2.1 (GND), U3.16 (-VOUT), U4.4 (GND1)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
GND1: C32.2, C34.2, C39.2, C40.2, D2.3, J7.4, U5.5 (GND2), U7.6 (0V), U7.7 (0V)
GND2: C31.2, C33.2, C35.2, C36.2, D1.3, J6.4, U4.5 (GND2), U6.6 (0V), U6.7 (0V)
GNDPWR: J8.2, J8.4, J8.6, J8.8, J8.10, J9.2, J9.4, J9.6, J9.8, J9.10, U8.3, U9.3, U10.3, U11.3, U12.3, U13.3, U14.3, U15.3, U16.3, U17.3
GND_ISO_UART3: C57.2, C59.2, C60.2, C61.2, J16.2, J16.4, U43.5 (GND), U44.1 (GND), U45.6 (0V), U45.7 (0V)
HSE_IN: R2.2, U1.12 (PH0)
HSE_OUT: C17.2, U1.13 (PH1), Y2.1
IND1_V24: J8.1, U8.4
IND2_V24: J8.3, U9.4
IND3_V24: J8.5, U10.4
IND4_V24: J8.7, U11.4
IND5_V24: J8.9, U12.4
IND6_V24: J9.1, U13.4
IND7_V24: J9.3, U14.4
IND8_V24: J9.5, U15.4
IND9_V24: J9.7, U16.4
IND10_V24: J9.9, U17.4
LSE_IN: C13.2, U1.8 (PC14), Y1.2
LSE_OUT: C16.2, U1.9 (PC15), Y1.1
NRST: C15.1, J2.10, J14.5, SW1.1, U1.14 (NRST)
unnamed: BT1.1 (+), C1.2, JP1.1 (A), U1.6 (VBAT)
unnamed: C14.2, R2.1, Y2.3
unnamed: C33.1, R3.2, R5.2
unnamed: C34.1, R4.2, R6.2
unnamed: D4.1 (K), R97.1
unnamed: D5.1 (K), R98.1
unnamed: J1.2, R1.1
unnamed: C20.2, C62.2, J5.1, U3.2 (-VIN), U3.3 (-VIN)
unnamed: C20.1, C62.1, J5.2, U3.22 (+VIN), U3.23 (+VIN)
unnamed: J6.3, R7.2
unnamed: J7.3, R8.2
unnamed: C45.2, J10.1, J10.3, J10.5, J10.7, J10.9, U29.6 (0V), U29.7 (0V)
unnamed: J10.2, U18.2
unnamed: J10.4, U20.2
unnamed: J10.6, U22.2
unnamed: J10.8, U24.2
unnamed: J10.10, U26.2
unnamed: C43.2, J11.1, J11.3, J11.5, J11.7, J11.9, U28.6 (0V), U28.7 (0V)
unnamed: J11.2, U19.2
unnamed: J11.4, U21.2
unnamed: J11.6, U23.2
unnamed: J11.8, U25.2
unnamed: J11.10, U27.2
unnamed: C47.2, J12.1, J12.3, J12.5, J12.7, J12.9, U35.6 (0V), U35.7 (0V)
unnamed: J12.2, U30.2
unnamed: J12.4, U31.2
unnamed: J12.6, U32.2
unnamed: J12.8, U33.2
unnamed: J12.10, U34.2
unnamed: C54.2, J13.1, J13.3, J13.5, J13.7, J13.9, J13.11, J13.13, J13.15, J13.17, J13.19, J13.21, J13.22, J13.23, J13.24, U41.6 (0V), U41.7 (0V)
unnamed: J13.2, U36.2 (C1)
unnamed: J13.4, U36.3 (C2)
unnamed: J13.6, U37.2 (C1)
unnamed: J13.8, U37.3 (C2)
unnamed: J13.10, U38.2 (C1)
unnamed: J13.12, U38.3 (C2)
unnamed: J13.14, U39.2 (C1)
unnamed: J13.16, U39.3 (C2)
unnamed: J13.18, U40.2 (C1)
unnamed: J13.20, U40.3 (C2)
unnamed: J16.1, Q11.2 (S), R92.2
unnamed: J16.3, Q12.2 (S), R95.2
unnamed: J17.2, R107.1
unnamed: J17.4, R105.1
unnamed: Q1.3 (D), R61.2, U36.7 (VO1)
unnamed: Q2.3 (D), R64.2, U36.6 (VO2)
unnamed: Q3.3 (D), R67.2, U37.7 (VO1)
unnamed: Q4.3 (D), R70.2, U37.6 (VO2)
unnamed: Q5.3 (D), R73.2, U38.7 (VO1)
unnamed: Q6.3 (D), R76.2, U38.6 (VO2)
unnamed: Q7.3 (D), R79.2, U39.7 (VO1)
unnamed: Q8.3 (D), R82.2, U39.6 (VO2)
unnamed: Q9.3 (D), R85.2, U40.7 (VO1)
unnamed: Q10.3 (D), R88.2, U40.6 (VO2)
unnamed: Q11.3 (D), R91.2, U43.7 (VO1)
unnamed: C61.1, Q11.1 (G), Q12.1 (G), R92.1, R95.1, U44.2 (VO)
unnamed: Q12.3 (D), R94.2, U43.6 (VO2)
unnamed: R21.1, U8.2
unnamed: R22.1, U9.2
unnamed: R23.1, U10.2
unnamed: R24.1, U11.2
unnamed: R25.1, U12.2
unnamed: R26.1, U13.2
unnamed: R27.1, U14.2
unnamed: R28.1, U15.2
unnamed: R29.1, U16.2
unnamed: R30.1, U17.2
unnamed: R33.2, U18.1
unnamed: R34.2, U19.1
unnamed: R37.2, U20.1
unnamed: R38.2, U21.1
unnamed: R41.2, U22.1
unnamed: R42.2, U23.1
unnamed: R45.2, U24.1
unnamed: R46.2, U25.1
unnamed: R49.2, U26.1
unnamed: R50.2, U27.1
unnamed: R52.2, U30.1
unnamed: R54.2, U31.1
unnamed: R56.2, U32.1
unnamed: R58.2, U33.1
unnamed: R60.2, U34.1
unnamed: C18.1, U1.49 (VCAP_1)
unnamed: C19.1, U1.73 (VCAP_2)
unnamed: C31.1, C35.1, C36.1, R7.1, U4.8 (VCC2), U6.8 (+Vo)
unnamed: C32.1, C39.1, C40.1, R8.1, U5.8 (VCC2), U7.8 (+Vo)
unnamed: C43.1, R34.1, R38.1, R42.1, R46.1, R50.1, U28.8 (+Vo)
unnamed: C45.1, R33.1, R37.1, R41.1, R45.1, R49.1, U29.8 (+Vo)
unnamed: C47.1, R52.1, R54.1, R56.1, R58.1, R60.1, U35.8 (+Vo)
unnamed: R63.2, U36.1 (A1)
unnamed: R66.2, U36.4 (A2)
unnamed: R69.2, U37.1 (A1)
unnamed: R72.2, U37.4 (A2)
unnamed: R75.2, U38.1 (A1)
unnamed: R78.2, U38.4 (A2)
unnamed: R81.2, U39.1 (A1)
unnamed: R84.2, U39.4 (A2)
unnamed: R87.2, U40.1 (A1)
unnamed: R90.2, U40.4 (A2)
unnamed: C54.1, R63.1, R66.1, R69.1, R72.1, R75.1, R78.1, R81.1, R84.1, R87.1, R90.1, U41.8 (+Vo)
unnamed: R93.2, U43.1 (A1)
unnamed: R96.2, U43.4 (A2)
PushSwitch_Stop_board: R57.1, U33.4
PushSwitch_Stop_cocpit: R59.1, U34.4
PushSwitch_Sync: R55.1, U32.4
SDIO_CLK: J4.5 (CLK), U1.80 (PC12)
SDIO_CMD: J4.3 (CMD), R102.2, U1.83 (PD2)
SDIO_DAT0: J4.7 (DAT0), R101.2, U1.65 (PC8)
SDIO_DAT1: J4.8 (DAT1), R100.2, U1.66 (PC9)
SDIO_DAT2: J4.1 (DAT2), R104.2, U1.78 (PC10)
SDIO_DAT3: J4.2 (DAT3/CD), R103.2, U1.79 (PC11)
SD_CD: J4.9 (DET), R99.2, U1.84 (PD3)
SWD_SWCLK: J2.4, J14.3, U1.76 (PA14)
SWD_SWDIO: J2.2, J14.1, U1.72 (PA13)
SWD_SWO: J2.6, U1.89 (PB3)
ThrustLever1: R107.2, R108.2, U1.35 (PB0)
ThrustLever2: R105.2, R106.2, U1.36 (PB1)
ToggleSwitch_AircraftPWR: R53.1, U31.4
ToggleSwitch_AirfieldPWR: R51.1, U30.4
ToggleSwitch_Bat1: R32.1, U19.4
ToggleSwitch_Bat2: R36.1, U21.4
ToggleSwitch_Bat3: R40.1, U23.4
ToggleSwitch_Bat4: R44.1, U25.4
ToggleSwitch_Bat_GND: R48.1, U27.4
ToggleSwitch_Imp1: R31.1, U18.4
ToggleSwitch_Imp2: R35.1, U20.4
ToggleSwitch_Imp3: R39.1, U22.4
ToggleSwitch_Imp4: R43.1, U24.4
ToggleSwitch_Imp5: R47.1, U26.4
USART3_RX: R96.1, U1.56 (PD9)
USART3_TX: R93.1, U1.55 (PD8)
USB_D+: U1.71 (PA12), U42.1 (I/O1)
USB_D-: U1.70 (PA11), U42.3 (I/O2)
VDD_3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C63.2, D5.2 (A), J1.1, J2.1, J4.4 (VDD), J14.4, JP1.2 (B), Q1.1 (G), Q2.1 (G), Q3.1 (G), Q4.1 (G), Q5.1 (G), Q6.1 (G), Q7.1 (G), Q8.1 (G), Q9.1 (G), Q10.1 (G), R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R31.2, R32.2, R35.2, R36.2, R39.2, R40.2, R43.2, R44.2, R47.2, R48.2, R51.2, R53.2, R55.2, R57.2, R59.2, R62.1, R65.1, R68.1, R71.1, R74.1, R77.1, R80.1, R83.1, R86.1, R89.1, R99.1, R100.1, R101.1, R102.1, R103.1, R104.1, U1.11 (VDD), U1.19 (VDD)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
VDD_5V0: C21.1, C22.1, C23.1, C37.1, C38.1, C41.1, C42.1, C44.1, C46.1, C48.1, C49.2, C50.2, C51.2, C52.2, C53.2, C55.1, C58.1, D3.1 (K), D4.2 (A), J17.1, J17.3, R61.1, R64.1, R67.1, R70.1, R73.1, R76.1, R79.1, R82.1, R85.1, R88.1, U2.3 (VI), U3.14 (+VOUT), U6.13 (Vin), U6.14 (Vin), U7.13 (Vin), U7.14 (Vin), U28.13 (Vin), U28.14 (Vin), U29.13 (Vin), U29.14 (Vin), U35.13 (Vin), U35.14 (Vin), U36.8 (VCC), U37.8 (VCC), U38.8 (VCC), U39.8 (VCC), U40.8 (VCC), U41.13 (Vin), U41.14 (Vin), U42.5 (VBUS), U45.13 (Vin), U45.14 (Vin)
VDD_5V0_ISO_UART3: C57.1, C59.1, C60.1, R91.1, R94.1, U43.8 (VCC), U44.3 (VI), U45.8 (+Vo)
VDD_5V_VBUS: C56.1, D3.2 (A), J3.1 (VBUS)

File Hardware/ciam/impeller/impeller/BOM_плата_кпу.xlsx:

Reference | Value | Footprint | Ссылка | Цена | Человекопонятное название | Кол. | Кол-во с запасом | Сумма
BT1 | KLS5-CR2032-01 | user_lib:KLS5-CR2032-01 | https://www.chipdip.ru/product/bh-642 | 16 | Разъем для плоской батарейки 3В | 1 | 3 | 48
C1, C2, C4, C7-C12, C15, C56, C63 | 100n | Capacitor_SMD:C_0603_1608Metric | https://www.chipdip.ru/product/grm188r71h104k | 19 | Конденсатор 100нФ | 12 | 36 | 684
C3, C5 | 1u | Capacitor_SMD:C_0603_1608Metric | https://www.chipdip.ru/product/grm188r71c105ka12d | 20 | Конденсатор 1мкФ | 2 | 6 | 120
C6 | 4u7 | Capacitor_SMD:C_0603_1608Metric | https://www.chipdip.ru/product0/9000348448 | 21 | Конденсатор 4.7мкФ | 1 | 3 | 63
C13, C14, C16, C17 | 15p | Capacitor_SMD:C_0603_1608Metric | https://www.chipdip.ru/product/grm1885c2a150j | 6 | Конденсатор 15пФ | 4 | 12 | 72
C18, C19 | 2u2 | Capacitor_SMD:C_0603_1608Metric | https://www.chipdip.ru/product/grm188r61a225k | 11 | Конденсатор 2.2мкФ | 2 | 6 | 66
C20, C22, C25, C44, C46, C48, C55, C58, C61 | 4u7 | Capacitor_SMD:C_0805_2012Metric | https://www.chipdip.ru/product/grm21br61e475ka12l | 13 | Конденсатор 4.7мкФ | 9 | 27 | 351
C21, C24 | 47u | Capacitor_SMD:CP_Elec_6.3x5.4 | https://www.chipdip.ru/product0/9000565730 | 16 | Конденсатор 47мкФ | 2 | 6 | 96
C23, C26, C28, C30, C35, C38, C39, C42, C49-C53, C57, C60, C62 | 100n | Capacitor_SMD:C_0805_2012Metric | https://www.chipdip.ru/product/grm21br71h104k | 13 | Конденсатор 100нФ | 16 | 48 | 624
C27, C29, C31, C32 | 1u | Capacitor_SMD:C_0805_2012Metric | https://www.chipdip.ru/product/grm21br71e105k | 13 | Конденсатор 1мкФ | 4 | 12 | 156
C33, C34 | 4n7 | Capacitor_SMD:C_0805_2012Metric | https://www.chipdip.ru/product/grm216r71h472k | 8 | Конденсатор 4.7нФ | 2 | 6 | 48
C36, C37, C40, C41, C43, C45, C47, C54, C59 | 10u | Capacitor_SMD:C_0805_2012Metric | https://www.chipdip.ru/product/grm21br61e106ka73l | 13 | Конденсатор 10мкФ | 9 | 27 | 351
D1, D2 | PESD1CAN | Package_TO_SOT_SMD:SOT-23 | https://www.chipdip.ru/product/pesd1can.215 | 87 | Защитный диод от ESD для CAN шины | 2 | 6 | 522
D3 | ss24 | user_lib:SS24 | https://www.chipdip.ru/product/ss24-umw | 5 | Диод Шоттки | 1 | 3 | 15
D4, D5 | FYLS-1206SRC | Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder | https://www.chipdip.ru/product0/8002031702 | 38 | Светодиод красный | 2 | 6 | 228
J1 | PLS-3 | Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical | https://www.chipdip.ru/product/pls-3 | 8 | Вилка штыревая 1x3 | 1 | 3 | 24
J5 | PicoBlade_1x2P | Connector_Molex:Molex_PicoBlade_53047-0210_1x02_P1.25mm_Vertical | https://www.chipdip.ru/product/sct1251wv-2p | 8 | Разъем Picoblade 1x2 | 1 | 3 | 24
J6, J7, J16, J17 | Micro-Fit_2x2P | Connector_Molex:Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal | https://www.chipdip.ru/product/sct3001wr-2x02p | 26 | Разъем Micro-Fit 2x2 М | 4 | 12 | 312
J8-J12 | Micro-Fit_2x5P | Connector_Molex:Molex_Micro-Fit_3.0_43045-1000_2x05_P3.00mm_Horizontal | https://www.chipdip.ru/product/sct3001wr-2x05p | 34 | Разъем Micro-Fit 2x5 М | 5 | 15 | 510
J13 | Micro-Fit_2x12P | Connector_Molex:Molex_Micro-Fit_3.0_43045-2400_2x12_P3.00mm_Horizontal | https://www.chipdip.ru/product/sct3001wr-2x12p | 51 | Разъем Micro-Fit 2x12 М | 1 | 3 | 153
J14 | PLS-5 | Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Vertical | https://www.chipdip.ru/product/pls-5 | 8 | Вилка штыревая 1x5 | 1 | 3 | 24
JP1 | PLS-2 | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical | https://www.chipdip.ru/product/pls-2 | 8 | Вилка штыревая 1x2 | 1 | 3 | 24
L1, L2 | B82789C0513H002 | user_lib:B82789C0513H002 | https://www.chipdip.ru/product0/8002015174 | 510 | Подавитель синфазных помех | 2 | 6 | 3060
Q1-Q12 | BSS138 | Package_TO_SOT_SMD:SOT-23 | https://www.chipdip.ru/product/bss138-umw | 3 | Транзистор полевой n типа | 12 | 36 | 108
R1, R9-R20, R31, R32, R35, R36, R39, R40, R43, R44, R47, R48, R51, R53, R55, R5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 | 10k | Resistor_SMD:R_0805_2012Metric | https://www.chipdip.ru/product/0.125w-0805-10-kom-5 | 5 | Резистор 10k Ом | 52 | 156 | 780
R2 | 0 | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-0-om-5 | 5 | Резистор 0 ОМ (перемычка) | 1 | 3 | 15
R7, R8 | 0 | Resistor_SMD:R_0805_2012Metric | https://www.chipdip.ru/product/0.125w-0805-peremychka-0-om | 5 | Резистор 0 ОМ (перемычка) | 2 | 6 | 30
R21-R30, R93, R96 | 220 | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-220-om-1 | 5 | Резистор 220 Ом | 12 | 36 | 180
R33, R34, R37, R38, R41, R42, R45, R46, R49, R50, R52, R54, R56, R58, R60 | 360 | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-360-om-1 | 5 | Резистор 360 Ом | 15 | 45 | 225
R63, R66, R69, R72, R75, R78, R81, R84, R87, R90 | 330 | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-330-om-1 | 5 | Резистор 330 Ом | 10 | 30 | 150
R97 | 150 | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/search?searchtext=150%D0%9E%D0%BC | 5 | Резистор 150 Ом | 1 | 3 | 15
R98 | 65 | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-75-om-1 | 5 | Резистор 65 Ом | 1 | 3 | 15
R99-R104 | 100k | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-100-kom-1 | 5 | Резистор 100k Ом | 6 | 18 | 90
R105, R107 | 1k | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-1-kom-1 | 5 | Резистор 1К ОМ | 2 | 6 | 30
R106, R108 | 2k | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-2-kom-1 | 5 | Резистор 2К ОМ | 2 | 6 | 30
SW1 | KLS7-TS6601-11-180 | Button_Switch_THT:SW_PUSH_6mm_H4.3mm | https://www.chipdip.ru/product/kls7-ts6601-11.0-180-it-1102k | 8 | Кнопка тактовая прямая | 1 | 3 | 24
SW2, SW3 | DS1040-06RN | Button_Switch_THT:SW_DIP_SPSTx06_Slide_9.78x17.42mm_W7.62mm_P2.54mm | https://www.chipdip.ru/product/ds1040-06rn | 38 | DIP переключатель 6pin красный | 2 | 6 | 228
U1 | STM32F405VGT6 | Package_QFP:LQFP-100_14x14mm_P0.5mm | https://www.chipdip.ru/product0/8884285457 | 930 | Микроконтроллер | 1 | 3 | 2790
U2, U44 | LDL1117S33R | Package_TO_SOT_SMD:SOT-223-3_TabPin2 | https://www.chipdip.ru/product/ldl1117s33r-stm | 33 | LDO-стабилизатор напряжения | 2 | 6 | 198
U3 | TEL 5-1211 | user_lib:TEL 5-1211 | https://www.chipdip.ru/product/tel-5-1211 | 2500 | DC-DC преобразователь | 1 | 3 | 7500
U4, U5 | ISO1050DUB | Package_SO:SOP-8_6.62x9.15mm_P2.54mm | https://energoflot.ru/item/ISO1050DUB | 225 | Изолированный приемопередатчик интерфейса CAN | 2 | 6 | 1350
U6, U7, U28, U29, U35, U41, U45 | B0505MT-1WR4 | user_lib:B0505MT-1WR4 | https://www.chipdip.ru/product0/8003333290 | 120 | DC/DC преобразователь | 7 | 21 | 2520
U8-U17 | G3VM61D1 | user_lib:G3VM61D1 | https://www.chipdip.ru/product0/8006782491 | 710 | Оптореле | 10 | 30 | 21300
U18-U27, U30-U34 | TLP291 | Package_SO:SOIC-4_4.55x2.6mm_P1.27mm | https://www.chipdip.ru/product/tlp291-gb-tp-se-t | 62 | Оптопара с транзисторным выходом | 15 | 45 | 2790
U42 | USBLC6-2SC6 | Package_TO_SOT_SMD:SOT-23-6 | https://www.chipdip.ru/product/usblc6-2sc6 | 25 | Защита интерфейса USB от электростатических разрядов | 1 | 3 | 75
Y1 | KSE-7K32768KDY2400A3 | user_lib:KSE-7K32768KDY2400A3 | https://www.chipdip.ru/product0/8022143960 | 34 | Кристаллический резонатор 32КГц | 1 | 3 | 102
Y2 | KSE-7U08000MAB143ZA3 | user_lib:KSE-7U08000MAB143ZA3 | https://www.chipdip.ru/product0/8022069891 | 12 | Кристаллический резонатор 8МГц | 1 | 3 | 36
 |  |  |  |  |  |  |  | СУММА
 |  |  |  |  |  |  |  | 48156

## Commit log

2022-08-19 added documentation
2022-08-19 added tight kicad template
2022-10-11 updated documentation
2022-10-11 updated footprints
2022-10-11 updated 3d models
2022-10-11 added FC0
2022-10-12 updated FC0
    added information about silkscreen errors
    fixed silkscreen errors
2023-01-22 updated fc0
2023-02-12 added logos folder
2023-02-12 updated kicad user lib
2023-02-15 added FC1 R3
2023-02-16 updated fc0 cube project
2023-03-16 created ibom
2023-03-19 changed project folders naming
2023-03-19 changed 1.3 file names
2023-03-19 moved all royal penguin pcbs to one folder
2023-06-28 added 3d models
2023-06-28 added footprints
2023-06-28 added v2.0
2023-07-30 added impeller project
2023-08-02 updated ciam project
2023-08-07 updated impeller project
2023-08-08 multiple fixes
2023-08-08 fixed bug in encoders sheet
2023-08-08 updated bom
2023-08-10 updated component info
2023-08-14 changed 12-5V dc-dc converter
2023-08-16 updated general scheme
2023-08-16 added thrust lever
2023-08-16 updated thrust level voltage divider
2023-08-16 added power shield project
2023-08-23 added rpi shield project
2023-08-23 Update CIAM project
2023-08-24 added rpi uart isolation
2023-08-25 fixed uart
2023-10-16 Updated penguin project
2023-11-02 Updated project
2023-12-27 Update Penguin project
2024-02-24 added Piezo sensor board project
2024-02-24 updated gitignore
    added altium designer
2024-02-25 Added power 10V0
2024-02-26 Started ADC file
2024-02-26 Updated .gitignore
2024-02-28 Penguin Junior 1.1 release
2024-02-28 Minor changes
2024-02-29 Added CPU
2024-03-01 cxdfgtyu
2024-03-04 Updated MCU
2024-03-05 Plased boot0 switch
2024-03-13 Another update
2024-03-13 Updated KiCad version
2024-03-14 added empty projects for main board, sensor module, imu module
2024-03-14 added master board schematic
2024-03-14 changed xt60 to xt30
2024-03-14 bugfix
2024-03-14 Master board сoncept
2024-03-15 added spi flash memory
2024-03-15 minor fixes
2024-03-15 added piezo module schematic (early version)
2024-03-16 added solder jumpers for 120R CAN
2024-03-16 Added UART port
2024-03-16 updated piezo module
2024-03-16 PCB prototype
2024-03-17 New best debug connector model
2024-03-20 Concept no trace
2024-03-20 added fram memory instead of flash
2024-03-20 Revert "added fram memory instead of flash"
    This reverts commit a8842e0ca394466531ab1a7069a2a0442e554849.
2024-03-21 added band pass filter to piezo board
2024-03-21 updated piezo board schematics
2024-03-22 Pre-production
2024-03-24 added imu module schematic
2024-03-25 Piezo concept (full)
2024-03-25 added platypus logo
2024-03-25 updated platypus logo
2024-03-28 Finished piezo board
2024-03-28 Piezo production
2024-03-29 Piezo fixes
2024-03-30 Master board pre-production
2024-03-30 Master and Piezo ready to production
2024-03-31 Master and Piezo fixes
2024-04-01 created local 3d models folder for imu module
2024-04-04 IMU update
2024-04-06 renamed ciam impeller 5 project
2024-04-07 updated ciam18 schematics
2024-04-08 updated impeller18 schamatic
2024-04-13 updated schematics
2024-04-14 updated impeller18 schematics
2024-04-15 Update IMU
2024-04-16 Power update
2024-04-18 Added Li-Io balanserer
2024-04-21 updatec schematics
2024-04-21 Update power
2024-04-21 added bat voltage sensor
2024-04-22 IMU production
2024-04-22 bugfixes
2024-04-29 changed ads1120 supply voltaged to 5v0
2024-05-01 Updated packeges
2024-05-01 Archive packeges
2024-05-01 updated vdri capasitors
2024-05-01 added bom for non-pcb components
2024-05-01 fixed switches
2024-05-02 fixed led indicators
2024-05-03 PCB concept
2024-05-06 Update PCB concept
2024-05-07 Daily PCB update
2024-06-02 Zone borders
2024-06-05 Sch ready
2024-06-05 Update CIAM
2024-06-05 CIAM update
2024-06-06 PCB production
2024-06-07 Silkscreen bugfix
2024-06-07 Drill bugfix
2024-06-08 Ibom update
2024-07-11 Penguin Junior 1.2 prototype
2024-07-12 Update Penguin concept
2024-07-16 Add readme
2024-08-03 Update 1.2 project
2024-08-06 Penguin Junior 1.2 production
2024-09-19 Penguin Junior 1.2 production last stable
