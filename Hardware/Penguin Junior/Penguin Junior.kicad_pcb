# Repository AeroKITties/Kitties-Hardware (continued)

## KiCad design Hardware/ciam/impeller18/impeller18.kicad_pcb (continued)

Schematic: stm32_peripherals.kicad_sch

Parts:
C108, C109, C110: 100n; C_0603_1608Metric
D21, D22, D23, D24: FYLS-3528RGBC; LED_RGB_promelec
J21: TF-01; TF01A-NEW
J22: USB_B_Micro; U-F-M5DD-W-2-SUS
R259, R260, R267, R268, R269, R270, R271, R272, R273, R274, R275, R276: 220; R_0603_1608Metric
R261, R262, R263, R264, R265, R266, R277, R278: 10k; R_0603_1608Metric
U73: W25Q128FVSIG; SOIC-8_5.23x5.23mm_P1.27mm
U74: USBLC6-2SC6; SOT-23-6

Connections:
3V3: C108.1, C109.2, D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), J21.4 (VDD), R261.1, R262.1, R263.1, R264.1, R265.1, R266.1, U73.7 (IO3), U73.8 (VCC); also elsewhere on the board
/STM32 Peripherals/usb_conn_d+: J22.3 (D+), U74.6 (I/O1)
/STM32 Peripherals/usb_conn_d-: J22.2 (D-), U74.4 (I/O2)
GND: C108.2, C109.1, C110.2, J21.6 (VSS), J21.10 (SHIELD), J22.5 (GND), J22.6 (Shield), R278.2, U73.4 (GND), U74.2 (GND); also elsewhere on the board
LED1_RGB_BLUE: R269.2
LED1_RGB_GREEN: R267.2
LED1_RGB_RED: R259.2
LED2_RGB_BLUE: R275.2
LED2_RGB_GREEN: R273.2
LED2_RGB_RED: R271.2
LED3_RGB_BLUE: R270.2
LED3_RGB_GREEN: R268.2
LED3_RGB_RED: R260.2
LED4_RGB_BLUE: R276.2
LED4_RGB_GREEN: R274.2
LED4_RGB_RED: R272.2
unnamed: D21.3 (BK), R269.1
unnamed: D21.4 (GK), R267.1
unnamed: D21.1 (RK), R259.1
unnamed: D22.3 (BK), R270.1
unnamed: D22.4 (GK), R268.1
unnamed: D22.1 (RK), R260.1
unnamed: D23.3 (BK), R275.1
unnamed: D23.4 (GK), R273.1
unnamed: D23.1 (RK), R271.1
unnamed: D24.3 (BK), R276.1
unnamed: D24.4 (GK), R274.1
unnamed: D24.1 (RK), R272.1
unnamed: C110.1, J22.1 (VBUS), R277.1, U74.5 (VBUS)
SDIO_CLK: J21.5 (CLK); also elsewhere on the board
SDIO_CMD: J21.3 (CMD), R264.2; also elsewhere on the board
SDIO_DAT0: J21.7 (DAT0), R263.2; also elsewhere on the board
SDIO_DAT1: J21.8 (DAT1), R262.2; also elsewhere on the board
SDIO_DAT2: J21.1 (DAT2), R266.2; also elsewhere on the board
SDIO_DAT3: J21.2 (DAT3/CD), R265.2; also elsewhere on the board
SD_CD: J21.9 (DET), R261.2
SPI1_STM32_CLK: U73.6 (CLK); also elsewhere on the board
SPI1_STM32_FLASH_CS: U73.1 (~CS); also elsewhere on the board
SPI1_STM32_MISO: U73.2 (DO(IO1)); also elsewhere on the board
SPI1_STM32_MOSI: U73.5 (DI(IO0)); also elsewhere on the board
USB_D+: U74.1 (I/O1); also elsewhere on the board
USB_D-: U74.3 (I/O2); also elsewhere on the board
USB_VBUS: R277.2, R278.1; also elsewhere on the board

Notes on the sheet:
Micro SD card
LED RGB
USB
Flash memory

Schematic: indicators.kicad_sch

Parts:
C88: 470u; CP_Radial_D12.5mm_P5.00mm
C89: 100u; CP_Radial_D8.0mm_P3.50mm
D17: FYLS-0603BUGC; LED_0603_1608Metric
J15: 430450600
J16, J17: 430451800
R168, R169, R170, R171, R172, R173, R174, R175, R176, R177, R178, R179, R180, R181, R182, R183, R184, R185, R186, R187, R188: 220; R_0603_1608Metric
R189: 470; R_0603_1608Metric
TP25, TP26: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
U35, U36, U37, U38, U39, U40, U41, U42, U43, U44, U45, U46, U47, U48, U49, U50, U51, U52, U53, U54, U55: G3VM61VY2; G3VM-61VY2TR
U56: SCWN06A-12

Connections:
3V3: R168.1, R169.1, R170.1, R171.1, R172.1, R173.1, R174.1, R175.1, R176.1, R177.1, R178.1, R179.1, R180.1, R181.1, R182.1, R183.1, R184.1, R185.1, R186.1, R187.1, R188.1; also elsewhere on the board
12V0: U56.22 (+VIN), U56.23 (+VIN); also elsewhere on the board
12V0_LED: C88.1, C89.1, J15.2, J15.4, J15.6, J16.2, J16.4, J16.6, J16.8, J16.10, J16.12, J16.14, J16.16, J16.18, J17.2, J17.4, J17.6, J17.8, J17.10, J17.12, J17.14, J17.16, J17.18, R189.1, TP25.1, U56.14 (+VOUT)
/LED_indicators/LED1_EXT_12V: J16.1, U35.3
/LED_indicators/LED2_EXT_12V: J16.3, U38.3
/LED_indicators/LED3_EXT_12V: J16.5, U41.3
/LED_indicators/LED4_EXT_12V: J16.7, U44.3
/LED_indicators/LED5_EXT_12V: J16.9, U46.3
/LED_indicators/LED6_EXT_12V: J16.11, U48.3
/LED_indicators/LED7_EXT_12V: J16.13, U50.3
/LED_indicators/LED8_EXT_12V: J16.15, U52.3
/LED_indicators/LED9_EXT_12V: J16.17, U54.3
/LED_indicators/LED10_EXT_12V: J17.1, U36.3
/LED_indicators/LED11_EXT_12V: J17.3, U39.3
/LED_indicators/LED12_EXT_12V: J17.5, U42.3
/LED_indicators/LED13_EXT_12V: J17.7, U45.3
/LED_indicators/LED14_EXT_12V: J17.9, U47.3
/LED_indicators/LED15_EXT_12V: J17.11, U49.3
/LED_indicators/LED16_EXT_12V: J17.13, U51.3
/LED_indicators/LED17_EXT_12V: J17.15, U53.3
/LED_indicators/LED18_EXT_12V: J17.17, U55.3
/LED_indicators/LED19_EXT_12V: J15.1, U37.3
/LED_indicators/LED20_EXT_12V: J15.3, U40.3
/LED_indicators/LED21_EXT_12V: J15.5, U43.3
GND_12V: U56.2 (-VIN), U56.3 (-VIN); also elsewhere on the board
GND_LED: C88.2, C89.2, D17.1 (K), TP26.1, U35.4, U36.4, U37.4, U38.4, U39.4, U40.4, U41.4, U42.4, U43.4, U44.4, U45.4, U46.4, U47.4, U48.4, U49.4, U50.4, U51.4, U52.4, U53.4, U54.4, U55.4, U56.16 (-VOUT)
LED1_EXT: U35.2
LED2_EXT: U38.2
LED3_EXT: U41.2
LED4_EXT: U44.2
LED5_EXT: U46.2
LED6_EXT: U48.2
LED7_EXT: U50.2
LED8_EXT: U52.2
LED9_EXT: U54.2
LED10_EXT: U36.2
LED11_EXT: U39.2
LED12_EXT: U42.2
LED13_EXT: U45.2
LED14_EXT: U47.2
LED15_EXT: U49.2
LED16_EXT: U51.2
LED17_EXT: U53.2
LED18_EXT: U55.2
LED19_EXT: U37.2
LED20_EXT: U40.2
LED21_EXT: U43.2
unnamed: D17.2 (A), R189.2
unnamed: R168.2, U35.1
unnamed: R169.2, U36.1
unnamed: R170.2, U37.1
unnamed: R171.2, U38.1
unnamed: R172.2, U39.1
unnamed: R173.2, U40.1
unnamed: R174.2, U41.1
unnamed: R175.2, U42.1
unnamed: R176.2, U43.1
unnamed: R177.2, U44.1
unnamed: R178.2, U45.1
unnamed: R179.2, U46.1
unnamed: R180.2, U47.1
unnamed: R181.2, U48.1
unnamed: R182.2, U49.1
unnamed: R183.2, U50.1
unnamed: R184.2, U51.1
unnamed: R185.2, U52.1
unnamed: R186.2, U53.1
unnamed: R187.2, U54.1
unnamed: R188.2, U55.1

Notes on the sheet:
32.4 м

Schematic: digital_inputs.kicad_sch

Parts:
J20: 430451600
R243, R245, R247, R249, R251, R253, R255, R257: 390; R_0603_1608Metric
R244, R246, R248, R250, R252, R254, R256, R258: 10k; R_0603_1608Metric
U71, U72: TLP291-4; SOIC-16_4.55x10.3mm_P1.27mm

Connections:
3V3: R244.2, R246.2, R248.2, R250.2, R252.2, R254.2, R256.2, R258.2; also elsewhere on the board
/Digital inputs 5V/INPUT_1_NEG: J20.2, U71.2
/Digital inputs 5V/INPUT_1_POS: J20.1, R243.1
/Digital inputs 5V/INPUT_2_NEG: J20.4, U71.4
/Digital inputs 5V/INPUT_2_POS: J20.3, R245.1
/Digital inputs 5V/INPUT_3_NEG: J20.6, U71.6
/Digital inputs 5V/INPUT_3_POS: J20.5, R247.1
/Digital inputs 5V/INPUT_4_NEG: J20.8, U71.8
/Digital inputs 5V/INPUT_4_POS: J20.7, R249.1
/Digital inputs 5V/INPUT_5_NEG: J20.10, U72.2
/Digital inputs 5V/INPUT_5_POS: J20.9, R251.1
/Digital inputs 5V/INPUT_6_NEG: J20.12, U72.4
/Digital inputs 5V/INPUT_6_POS: J20.11, R253.1
/Digital inputs 5V/INPUT_7_NEG: J20.14, U72.6
/Digital inputs 5V/INPUT_7_POS: J20.13, R255.1
/Digital inputs 5V/INPUT_8_NEG: J20.16, U72.8
/Digital inputs 5V/INPUT_8_POS: J20.15, R257.1
DIGITAL_IN_1: R244.1, U71.16
DIGITAL_IN_2: R246.1, U71.14
DIGITAL_IN_3: R248.1, U71.12
DIGITAL_IN_4: R250.1, U71.10
DIGITAL_IN_5: R252.1, U72.16
DIGITAL_IN_6: R254.1, U72.14
DIGITAL_IN_7: R256.1, U72.12
DIGITAL_IN_8: R258.1, U72.10
GND: U71.9, U71.11, U71.13, U71.15, U72.9, U72.11, U72.13, U72.15; also elsewhere on the board
unnamed: R243.2, U71.1
unnamed: R245.2, U71.3
unnamed: R247.2, U71.5
unnamed: R249.2, U71.7
unnamed: R251.2, U72.1
unnamed: R253.2, U72.3
unnamed: R255.2, U72.5
unnamed: R257.2, U72.7

Schematic: switches_2.kicad_sch

Parts:
C84, C87: 100n; C_0603_1608Metric
C85, C86: 10u; C_0603_1608Metric
D16: FYLS-0603BUGC; LED_0603_1608Metric
J11: 430451000
J12, J14: 430450600
J13: 430450400; 430454000
J28: 430450800
Q23, Q24, Q25, Q26, Q27, Q28, Q29, Q30, Q31, Q32, Q33, Q34, Q35: BSS138; SOT-23
R115, R119, R123, R127, R131, R136, R140, R144, R148, R152, R156, R160, R164: 1M; R_0603_1608Metric
R116, R120, R124, R128, R132, R137, R141, R145, R149, R153, R157, R161, R165: 360k; R_0603_1608Metric
R117, R121, R125, R129, R133, R134, R138, R142, R146, R150, R154, R158, R162, R166: 360; R_0603_1608Metric
R118, R122, R126, R130, R135, R139, R143, R147, R151, R155, R159, R163, R167, R305, R306, R307, R308, R309, R310, R311, R312, R313, R314, R315, R316, R317: 10k; R_0603_1608Metric
TP21, TP22: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
U27, U28: TLP291-4; SOIC-16_4.55x10.3mm_P1.27mm
U29: B0505MT-1WR4
U30, U31, U32, U33, U34: TLP291

Connections:
3V3: R118.2, R122.2, R126.2, R130.2, R135.2, R139.2, R143.2, R147.2, R151.2, R155.2, R159.2, R163.2, R167.2; also elsewhere on the board
5V0: C86.1, C87.1, U29.13 (Vin), U29.14 (Vin); also elsewhere on the board
5V0_SWITCHES_3: C84.1, C85.1, R133.2, R305.1, R306.1, R307.1, R308.1, R309.1, R310.1, R311.1, R312.1, R313.1, R314.1, R315.1, R316.1, R317.1, TP21.1, U27.1, U27.3, U27.5, U27.7, U28.1, U28.3, U28.5, U28.7, U29.8 (+Vo), U30.1, U31.1, U32.1, U33.1, U34.1
/Switches_2/SWITCH_3.1_EXT: J11.1, J28.1, R115.2
/Switches_2/SWITCH_3.2_EXT: J11.3, J28.3, R119.2
/Switches_2/SWITCH_3.3_EXT: J11.5, J28.5, R123.2
/Switches_2/SWITCH_3.4_EXT: J11.7, J28.7, R127.2
/Switches_2/SWITCH_3.5_EXT: J11.9, J28.2, R131.2
/Switches_2/SWITCH_3.6_EXT: J12.1, J28.4, R136.2
/Switches_2/SWITCH_3.7_EXT: J12.3, J28.6, R140.2
/Switches_2/SWITCH_3.8_EXT: J12.5, J28.8, R144.2
/Switches_2/SWITCH_3.9_EXT: J13.1, R148.2
/Switches_2/SWITCH_3.10_EXT: J13.3, R152.2
/Switches_2/SWITCH_4.1_EXT: J14.1, R156.2
/Switches_2/SWITCH_4.2_EXT: J14.3, R160.2
/Switches_2/SWITCH_4.3_EXT: J14.5, R164.2
GND: C86.2, C87.2, U27.9, U27.11, U27.13, U27.15, U28.9, U28.11, U28.13, U28.15, U29.1 (gnd), U29.2 (gnd), U30.3, U31.3, U32.3, U33.3, U34.3; also elsewhere on the board
GND_IN: C84.2, C85.2, D16.1 (K), Q23.2 (S), Q24.2 (S), Q25.2 (S), Q26.2 (S), Q27.2 (S), Q28.2 (S), Q29.2 (S), Q30.2 (S), Q31.2 (S), Q32.2 (S), Q33.2 (S), Q34.2 (S), Q35.2 (S), R116.1, R120.1, R124.1, R128.1, R132.1, R137.1, R141.1, R145.1, R149.1, R153.1, R157.1, R161.1, R165.1, TP22.1, U29.6 (0V), U29.7 (0V); also elsewhere on the board
unnamed: D16.2 (A), R133.1
unnamed: Q23.3 (D), R117.1, R305.2
unnamed: Q23.1 (G), R115.1, R116.2
unnamed: Q24.3 (D), R121.1, R306.2
unnamed: Q24.1 (G), R119.1, R120.2
unnamed: Q25.3 (D), R125.1, R307.2
unnamed: Q25.1 (G), R123.1, R124.2
unnamed: Q26.3 (D), R129.1, R308.2
unnamed: Q26.1 (G), R127.1, R128.2
unnamed: Q27.3 (D), R134.1, R309.2
unnamed: Q27.1 (G), R131.1, R132.2
unnamed: Q28.3 (D), R138.1, R310.2
unnamed: Q28.1 (G), R136.1, R137.2
unnamed: Q29.3 (D), R142.1, R311.2
unnamed: Q29.1 (G), R140.1, R141.2
unnamed: Q30.3 (D), R146.1, R312.2
unnamed: Q30.1 (G), R144.1, R145.2
unnamed: Q31.3 (D), R150.1, R313.2
unnamed: Q31.1 (G), R148.1, R149.2
unnamed: Q32.3 (D), R154.1, R314.2
unnamed: Q32.1 (G), R152.1, R153.2
unnamed: Q33.3 (D), R158.1, R315.2
unnamed: Q33.1 (G), R156.1, R157.2
unnamed: Q34.3 (D), R162.1, R316.2
unnamed: Q34.1 (G), R160.1, R161.2
unnamed: Q35.3 (D), R166.1, R317.2
unnamed: Q35.1 (G), R164.1, R165.2
unnamed: R117.2, U27.2
unnamed: R121.2, U27.4
unnamed: R125.2, U27.6
unnamed: R129.2, U27.8
unnamed: R134.2, U28.2
unnamed: R138.2, U28.4
unnamed: R142.2, U28.6
unnamed: R146.2, U28.8
unnamed: R150.2, U30.2
unnamed: R154.2, U31.2
unnamed: R158.2, U32.2
unnamed: R162.2, U33.2
unnamed: R166.2, U34.2
SWITCH_3.1_3V3: R118.1, U27.16
SWITCH_3.2_3V3: R122.1, U27.14
SWITCH_3.3_3V3: R126.1, U27.12
SWITCH_3.4_3V3: R130.1, U27.10
SWITCH_3.5_3V3: R135.1, U28.16
SWITCH_3.6_3V3: R139.1, U28.14
SWITCH_3.7_3V3: R143.1, U28.12
SWITCH_3.8_3V3: R147.1, U28.10
SWITCH_3.9_3V3: R151.1, U30.4
SWITCH_3.10_3V3: R155.1, U31.4
SWITCH_4.1_3V3: R159.1, U32.4
SWITCH_4.2_3V3: R163.1, U33.4
SWITCH_4.3_3V3: R167.1, U34.4
VIN: J11.2, J11.4, J11.6, J11.8, J11.10, J12.2, J12.4, J12.6, J13.2, J13.4, J14.2, J14.4, J14.6; also elsewhere on the board

Notes on the sheet:
0.5 м
большая красная кнопка
1.8
800/24 АэрПит ПитСис
8 м
что планируется кроме большой красной кнопки и что мы посылаем в РУ1?
4 м
АКБ1 АКБ2 АКБ3 АКБ4 Общ-
0.9 м
14 м

Board: 2 copper layers, 693 parts (1 on the bottom side), 425 nets, no tracks yet.

## KiCad design Hardware/CAN sensor net/IMU module/IMU module.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C11, C12: 100n; C_0603_1608Metric
C6: 4u7; C_0603_1608Metric
C7: 10n; C_0603_1608Metric
C8: 1u; C_0603_1608Metric
C9, C10: 8p; C_0603_1608Metric
D1, D3: LED; LED_1206_3216Metric
D2: LED_RGBA; LED_RGB_Wuerth-PLCC4_3.2x2.8mm_150141M173100
JP1, JP2, JP3, JP4, JP5, JP6: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R8, R9, R10, R11, R12: 10k; R_0603_1608Metric
R2, R3, R4, R5, R6: 220; R_0603_1608Metric
R7: 4k7; R_0603_1608Metric
R13: 120; R_0603_1608Metric
SW1: SW_Push; button_small
SW2: SW_SPDT; SW_SPDT_PCM12
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12: TestPoint; TestPoint_Pad_D1.0mm
U1: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U2: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U3: W25Q32FVSSIG; SOIC-8_5.23x5.23mm_P1.27mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
ADDR_0: JP1.2 (B), R12.1, U2.12 (PA2)
ADDR_1: JP2.2 (B), R11.1, U2.3 (PC14)
ADDR_2: JP4.2 (B), R10.1, U2.10 (PA0)
ADDR_3: JP5.2 (B), R9.1, U2.4 (PC15)
ADDR_4: JP6.2 (B), R8.1, U2.41 (PB5)
BMI088A_CS: TP7.1, U2.27 (PB14); also elsewhere on the board
BMI088G_CS: TP6.1, U2.28 (PB15); also elsewhere on the board
BMI088_INT1: U2.29 (PA8); also elsewhere on the board
BMI088_INT2: U2.26 (PB13); also elsewhere on the board
BMI088_INT3: U2.31 (PA10); also elsewhere on the board
BMI088_INT4: U2.30 (PA9); also elsewhere on the board
BOOT0: R1.1, U2.44 (BOOT0)
CAN+: JP3.2 (B), U1.7 (CANH); also elsewhere on the board
CAN-: R13.2, U1.6 (CANL); also elsewhere on the board
CAN_RX: U1.4 (R), U2.45 (PB8)
CAN_TX: U1.1 (D), U2.46 (PB9)
DEBUG_SWCLK: TP9.1, U2.37 (PA14)
DEBUG_SWDIO: TP10.1, U2.34 (PA13)
DEBUG_SWO: TP8.1, U2.39 (PB3)
FLASH_CS: TP12.1, U2.21 (PB10), U3.1 (~CS)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, JP1.1 (A), JP2.1 (A), JP4.1 (A), JP5.1 (A), JP6.1 (A), R6.2, SW1.1, SW2.1 (A), SW2.MP, TP11.1, U1.2 (GND), U1.8 (Rs), U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U3.4 (GND), Y1.2, Y1.4; also elsewhere on the board
ICM42688P_CS: TP4.1, U2.13 (PA3); also elsewhere on the board
ICM42688P_INT1: U2.11 (PA1); also elsewhere on the board
ICM42688P_INT2: U2.14 (PA4); also elsewhere on the board
LED: R3.2, U2.2 (PC13)
LED_RGB_BLUE: R2.2, U2.25 (PB12)
LED_RGB_GREEN: R4.2, U2.19 (PB1)
LED_RGB_RED: R5.2, U2.18 (PB0)
NRST: C1.2, SW1.2, U2.7 (NRST)
unnamed: D1.1 (K), R3.1
unnamed: D2.3 (BK), R2.1
unnamed: D2.4 (GK), R4.1
unnamed: D2.1 (RK), R5.1
unnamed: D3.1 (K), R6.1
unnamed: JP3.1 (A), R13.1
unnamed: R1.2, SW2.2 (B)
RCC_OSC_IN: C9.2, U2.5 (PD0), Y1.1
RCC_OSC_OUT: C10.2, TP5.1, U2.6 (PD1), Y1.3
SPI_CLK: TP1.1, U2.15 (PA5), U3.6 (CLK); also elsewhere on the board
SPI_MISO: TP2.1, U2.16 (PA6), U3.2 (DO(IO1)); also elsewhere on the board
SPI_MOSI: TP3.1, U2.17 (PA7), U3.5 (DI(IO0)); also elsewhere on the board
UART1_RX: U2.43 (PB7); also elsewhere on the board
UART1_TX: U2.42 (PB6); also elsewhere on the board
USB_D+: R7.2, U2.33 (PA12); also elsewhere on the board
USB_D-: U2.32 (PA11); also elsewhere on the board
VBUS_DETECT: U2.20 (PB2); also elsewhere on the board
VDD_3V3: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C11.2, C12.2, D1.2 (A), D2.2 (A), D3.2 (A), R7.1, R8.2, R9.2, R10.2, R11.2, R12.2, SW2.3 (C), U1.3 (VCC), U2.1 (VBAT), U2.9 (VDDA), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U3.7 (IO3), U3.8 (VCC); also elsewhere on the board

Notes on the sheet:
VDDA
VDD
Address selection
VBAT
Flash memory
BOOT0
LED
CAN
HSE
Reset
Decoupling caps

Parts:
C13: 10n; C_0603_1608Metric
C14, C15: 1u; C_0603_1608Metric
D4, D5: PMEG2020EH; D_SOD-123F
U4: LD3985M33R_SOT23; SOT-23-5

Connections:
GND: C13.2, C14.2, C15.2, U4.2 (GND); also elsewhere on the board
unnamed: C15.1, D4.1 (K), D5.1 (K), U4.1 (VIN), U4.3 (INH)
unnamed: C13.1, U4.4 (BYP)
VDD_3V3: C14.1, U4.5 (VOUT); also elsewhere on the board
VDD_5V_USB: D5.2 (A); also elsewhere on the board
VDD_7V0: D4.2 (A); also elsewhere on the board

Notes on the sheet:
INH: >1.2V ON <0.4V OFF
OUT: 3.3V 150mA

Parts:
C16: 100n; C_0603_1608Metric
D6: PMEG2020EH; D_SOD-123F
J1, J2: 532610671; Molex_PicoBlade_53261-0671_1x06-1MP_P1.25mm_Horizontal
J3: USB_B_Micro; U-F-M5DD-W-2-SUS
J4: 530470310; Molex_PicoBlade_53261-0371_1x03-1MP_P1.25mm_Horizontal
R14, R15: 10k; R_0603_1608Metric
U5: USBLC6-2SC6; SOT-23-6

Connections:
/Connectors/usb_conn_d+: J3.3 (D+), U5.6 (I/O1)
/Connectors/usb_conn_d-: J3.2 (D-), U5.4 (I/O2)
CAN+: J1.4, J2.4; also elsewhere on the board
CAN-: J1.3, J2.3; also elsewhere on the board
GND: C16.2, J1.5, J1.6, J1.MP, J2.5, J2.6, J2.MP, J3.5 (GND), J3.6 (Shield), J4.1, J4.MP, R15.2, U5.2 (GND); also elsewhere on the board
unnamed: D6.1 (K), J4.2
UART1_RX: J4.3; also elsewhere on the board
UART1_TX: D6.2 (A); also elsewhere on the board
USB_D+: U5.1 (I/O1); also elsewhere on the board
USB_D-: U5.3 (I/O2); also elsewhere on the board
VBUS_DETECT: R14.2, R15.1; also elsewhere on the board
VDD_5V_USB: C16.1, J3.1 (VBUS), R14.1, U5.5 (VBUS); also elsewhere on the board
VDD_7V0: J1.1, J1.2, J2.1, J2.2; also elsewhere on the board

Notes on the sheet:
USB
UART

Parts:
C17, C22, C23: 100n; C_0603_1608Metric
C18: 2u2; C_0603_1608Metric
C19: 10n; C_0603_1608Metric
U6: BMI088; LGA-16_3x4.5x0.95mm
U7: ICM-42688-P; LGA-14_2.5x3x0.91mm

Connections:
BMI088A_CS: U6.14 (CSB1); also elsewhere on the board
BMI088G_CS: U6.5 (CSB2); also elsewhere on the board
BMI088_INT1: U6.16 (INT1); also elsewhere on the board
BMI088_INT2: U6.1 (INT2); also elsewhere on the board
BMI088_INT3: U6.12 (INT3); also elsewhere on the board
BMI088_INT4: U6.13 (INT4); also elsewhere on the board
GND: C17.2, C18.2, C19.2, C22.2, C23.2, U6.4 (GND), U6.6 (GNDIO), U6.7 (PS), U7.6 (GND), U7.7 (RESV); also elsewhere on the board
ICM42688P_CS: U7.12 (AP_CS); also elsewhere on the board
ICM42688P_INT1: U7.4 (INT1/INT); also elsewhere on the board
ICM42688P_INT2: U7.9 (INT2/FSYNC/CLKIN); also elsewhere on the board
SPI_CLK: U6.8 (SCL/SCK), U7.13 (AP_SCL/AP_SCLK); also elsewhere on the board
SPI_MISO: U6.10 (SDO2), U6.15 (SDO1), U7.1 (AP_SDO/AP_AD0); also elsewhere on the board
SPI_MOSI: U6.9 (SDA/SDI), U7.14 (AP_SDI/AP_SDA); also elsewhere on the board
VDD_3V3: C17.1, C18.1, C19.1, C22.1, C23.1, U6.3 (VDD), U6.11 (VDDIO), U7.5 (VDDIO), U7.8 (VDD); also elsewhere on the board

Notes on the sheet:
Gyro Accel BMI088
Gyro Accel ICM-42688-P

Board: 4 copper layers, 41.5 x 25.1 mm, 74 parts (12 on the bottom side), 54 nets.

## KiCad design Hardware/CAN sensor net/Master board/Master board.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C7, C9, C23, C24, C25: 100n; C_0603_1608Metric
C6: 4u7; C_0603_1608Metric
C8: 1u; C_0603_1608Metric
C10, C11: 8p; C_0603_1608Metric
C12, C13: 2u2; C_0603_1608Metric
D1, D8: LED_RGBA; LED_RGB_promelec
D5, D6, D7: LED; LED_1206_3216Metric
H1, H2, H3: MountingHole; MountingHole_2.2mm_M2_Pad_Via
JP2, JP3: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2, R3, R18, R19, R20, R21, R22, R23: 220; R_0603_1608Metric
R16, R17: 120; R_0603_1608Metric
R24: 10k; R_0603_1608Metric
SW1: SW_Push; button_small
SW2: SW_SPDT; SW_SPDT_PCM12
U1: STM32F405RGTx; LQFP-64_10x10mm_P0.5mm
U5, U6: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U7: W25Q32FVSSIG; SOIC-8_5.23x5.23mm_P1.27mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
BOOT0: R24.1, U1.60 (BOOT0)
CAN0_H+: JP2.2 (B), U5.7 (CANH); also elsewhere on the board
CAN0_L-: R16.1, U5.6 (CANL); also elsewhere on the board
CAN0_RX: U1.61 (PB8), U5.4 (R)
CAN0_TX: U1.62 (PB9), U5.1 (D)
CAN1_H+: R17.1, U6.7 (CANH); also elsewhere on the board
CAN1_L-: JP3.1 (A), U6.6 (CANL); also elsewhere on the board
CAN1_RX: U1.57 (PB5), U6.4 (R)
CAN1_TX: U1.58 (PB6), U6.1 (D)
DEBUG_SWCLK: U1.49 (PA14); also elsewhere on the board
DEBUG_SWDIO: U1.46 (PA13); also elsewhere on the board
DEBUG_SWO: U1.55 (PB3); also elsewhere on the board
FLASH_CS: U1.20 (PA4), U7.1 (~CS)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C23.1, C24.1, C25.1, R20.2, SW1.1, SW2.1 (A), SW2.MP, U1.12 (VSSA), U1.18 (VSS), U1.63 (VSS), U5.2 (GND), U5.8 (Rs), U6.2 (GND), U6.8 (Rs), U7.4 (GND), Y1.2, Y1.4; also elsewhere on the board
LED1_RGB_BLUE: R3.2, U1.37 (PC6)
LED1_RGB_GREEN: R2.2, U1.35 (PB14)
LED1_RGB_RED: R1.2, U1.34 (PB13)
LED2_RGB_BLUE: R23.2, U1.38 (PC7)
LED2_RGB_GREEN: R22.2, U1.36 (PB15)
LED2_RGB_RED: R21.2, U1.33 (PB12)
LED3: D5.1 (K), U1.59 (PB7)
LED4: R19.2, U1.41 (PA8)
NRST: C9.2, SW1.2, U1.7 (NRST); also elsewhere on the board
unnamed: D1.3 (BK), R3.1
unnamed: D1.4 (GK), R2.1
unnamed: D1.1 (RK), R1.1
unnamed: D5.2 (A), R18.1
unnamed: D6.1 (K), R19.1
unnamed: D7.1 (K), R20.1
unnamed: D8.3 (BK), R23.1
unnamed: D8.4 (GK), R22.1
unnamed: D8.1 (RK), R21.1
unnamed: JP2.1 (A), R16.2
unnamed: JP3.2 (B), R17.2
unnamed: R24.2, SW2.2 (B)
unnamed: C13.2, U1.31 (VCAP_1)
unnamed: C12.2, U1.47 (VCAP_2)
RCC_OSC_IN: C10.2, U1.5 (PH0), Y1.1
RCC_OSC_OUT: C11.2, U1.6 (PH1), Y1.3
SDIO_CK: U1.53 (PC12); also elsewhere on the board
SDIO_CMD: U1.54 (PD2); also elsewhere on the board
SDIO_D0: U1.39 (PC8); also elsewhere on the board
SDIO_D1: U1.40 (PC9); also elsewhere on the board
SDIO_D2: U1.51 (PC10); also elsewhere on the board
SDIO_D3: U1.52 (PC11); also elsewhere on the board
SD_CD: U1.11 (PC3); also elsewhere on the board
SPI_CLK: U1.21 (PA5), U7.6 (CLK)
SPI_MISO: U1.22 (PA6), U7.2 (DO(IO1))
SPI_MOSI: U1.23 (PA7), U7.5 (DI(IO0))
UART1_RX: U1.43 (PA10); also elsewhere on the board
UART1_TX: U1.42 (PA9); also elsewhere on the board
VBUS_DETECT: U1.30 (PB11); also elsewhere on the board
VDD_3V3: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C23.2, C24.2, C25.2, D1.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), R18.2, SW2.3 (C), U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U5.3 (VCC), U6.3 (VCC), U7.7 (IO3), U7.8 (VCC); also elsewhere on the board

Notes on the sheet:
VDDA
CAN
Reset
VDD
Flash memory
VBAT
BOOT0
Decoupling caps
LED
HSE

Parts:
C16, C18: 100n; C_0603_1608Metric
C17: 10u; C_1210_3225Metric
C19: 100u; CP_Radial_D5.0mm_P2.00mm
C20: 150p; C_0603_1608Metric
C21: 1u; C_0603_1608Metric
C22: 4u7; C_0603_1608Metric
D2: STPS3L60U; D_SMB
D3, D4: PMEG2020EH; D_SOD-123F
F1: RUEF300
J4: XT30; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
L1: 4u7; L_Sunlord_MWSA0503S
R12: 47k; R_0603_1608Metric
R13: 10k; R_0603_1608Metric
R14, R15: 1k; R_0603_1608Metric
U3: ST1S14PHR; TI_SO-PowerPAD-8
U4: LDL1117_3V3; SOT-223-3_TabPin2

Connections:
GND: C17.1, C18.1, C19.2, C21.2, C22.2, D2.2 (A), J4.1, R15.1, U3.3 (~EN1), U3.6 (GND), U3.9 (PADGND), U4.1 (GND); also elsewhere on the board
unnamed: C19.1, C20.2, F1.2, L1.2, R12.2, R13.2
unnamed: C16.2, D2.1 (K), L1.1, U3.8 (SW)
unnamed: C21.1, D3.1 (K), D4.1 (K), U4.3 (VI)
unnamed: C17.2, C18.2, J4.2, U3.5 (EN2), U3.7 (VIN)
unnamed: R14.1, R15.2
unnamed: C16.1, U3.1 (BOOT)
unnamed: C20.1, R13.1, R14.2, U3.4 (FB)
unnamed: R12.1, U3.2 (PG)
VDD_3V3: C22.1, U4.2 (VO); also elsewhere on the board
VDD_5V_USB: D4.2 (A); also elsewhere on the board
VDD_7V0: D3.2 (A), F1.1; also elsewhere on the board

Notes on the sheet:
r_2=r_1/((v/1.22)-1)
r_2
from 9V to 26V
SS36B
r_1
~7V3
