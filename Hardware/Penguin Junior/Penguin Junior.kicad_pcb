# Repository AeroKITties/Kitties-Hardware (continued)

## KiCad design Hardware/CAN sensor net/Master board/Master board.kicad_pcb (continued)

Parts:
C14, C15: 100n; C_0603_1608Metric
J1: Micro_SD_Card_Con; TF01A
J2: USB_B_Micro; U-F-M5DD-W-2-SUS
J3: Conn_02x05_SWD; PinHeader_2x05_P1.27mm_Vertical
J5, J6: 532610671; Molex_PicoBlade_53261-0671_1x06-1MP_P1.25mm_Horizontal
J7: 530470310; Molex_PicoBlade_53261-0371_1x03-1MP_P1.25mm_Horizontal
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R4, R5, R6, R7, R8, R9, R10, R11: 10k; R_0603_1608Metric
U2: USBLC6-2SC6; SOT-23-6

Connections:
CAN0_H+: J5.4; also elsewhere on the board
CAN0_L-: J5.3; also elsewhere on the board
CAN1_H+: J6.4; also elsewhere on the board
CAN1_L-: J6.3; also elsewhere on the board
DEBUG_SWCLK: J3.4; also elsewhere on the board
DEBUG_SWDIO: J3.2; also elsewhere on the board
DEBUG_SWO: J3.6; also elsewhere on the board
GND: C14.1, C15.2, J1.6 (VSS), J1.10 (SHIELD), J2.5 (GND), J2.6 (Shield), J3.3, J3.5, J3.9, J5.5, J5.6, J5.MP, J6.5, J6.6, J6.MP, J7.1, J7.MP, R10.2, U2.2 (GND); also elsewhere on the board
NRST: J3.10; also elsewhere on the board
unnamed: J3.1, JP1.2 (B)
SDIO_CK: J1.5 (CLK); also elsewhere on the board
SDIO_CMD: J1.3 (CMD), R7.2; also elsewhere on the board
SDIO_D0: J1.7 (DAT0), R6.2; also elsewhere on the board
SDIO_D1: J1.8 (DAT1), R5.2; also elsewhere on the board
SDIO_D2: J1.1 (DAT2), R9.2; also elsewhere on the board
SDIO_D3: J1.2 (DAT3/CD), R8.2; also elsewhere on the board
SD_CD: J1.9 (DET), R4.2; also elsewhere on the board
UART1_RX: J7.3; also elsewhere on the board
UART1_TX: J7.2; also elsewhere on the board
VBUS_DETECT: R10.1, R11.2; also elsewhere on the board
VDD_3V3: C14.2, J1.4 (VDD), JP1.1 (A), R4.1, R5.1, R6.1, R7.1, R8.1, R9.1; also elsewhere on the board
VDD_5V_USB: C15.1, J2.1 (VBUS), R11.1, U2.5 (VBUS); also elsewhere on the board
VDD_7V0: J5.1, J5.2, J6.1, J6.2; also elsewhere on the board

Notes on the sheet:
CAN
USB
Micro SD
UART
SWD (Debug)

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
Board: 4 copper layers, 58.5 x 28.9 mm, 82 parts (37 on the bottom side), 68 nets.

## KiCad design Hardware/CAN sensor net/Piezo module/Piezo module.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C11, C12: 100n; C_0603_1608Metric
C6: 4u7; C_0603_1608Metric
C7: 10n; C_0603_1608Metric
C8: 1u; C_0603_1608Metric
C9, C10: 8p; C_0603_1608Metric
D1, D3: LED; LED_1206_3216Metric
D2: LED_RGBA; LED_RGB_promelec
H1, H2: MountingHole; MountingHole_2.2mm_M2_Pad_Via
JP1, JP2, JP3, JP4, JP5, JP6: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R8, R9, R10, R11, R12: 10k; R_0603_1608Metric
R2, R3, R4, R5, R6: 220; R_0603_1608Metric
R7: 4k7; R_0603_1608Metric
R13: 120; R_0603_1608Metric
SW1: SW_Push; button_small
SW2: SW_SPDT; SW_SPDT_PCM12
TP5, TP6, TP7: TestPoint; TestPoint_THTPad_D1.0mm_Drill0.5mm
U1: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U2: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U3: W25Q32FVSSIG; SOIC-8_5.23x5.23mm_P1.27mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
ADC_CS: U2.14 (PA4); also elsewhere on the board
ADC_DRDY: U2.18 (PB0); also elsewhere on the board
ADDR_0: JP6.2 (B), R8.1, U2.4 (PC15)
ADDR_1: JP5.2 (B), R9.1, U2.27 (PB14)
ADDR_2: JP4.2 (B), R10.1, U2.26 (PB13)
ADDR_3: JP2.2 (B), R11.1, U2.25 (PB12)
ADDR_4: JP1.2 (B), R12.1, U2.22 (PB11)
BOOT0: R1.1, U2.44 (BOOT0)
CAN_+: JP3.1 (A), U1.7 (CANH); also elsewhere on the board
CAN_-: R13.1, U1.6 (CANL); also elsewhere on the board
CAN_RX: U1.4 (R), U2.45 (PB8)
CAN_TX: U1.1 (D), U2.46 (PB9)
FLASH_CS: U2.2 (PC13), U3.1 (~CS)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, JP1.1 (A), JP2.1 (A), JP4.1 (A), JP5.1 (A), JP6.1 (A), R6.2, SW1.1, SW2.1 (A), SW2.MP, U1.2 (GND), U1.8 (Rs), U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U3.4 (GND), Y1.2, Y1.4; also elsewhere on the board
LED: R3.2, U2.40 (PB4)
LED_RGB_BLUE: R5.2, U2.11 (PA1)
LED_RGB_GREEN: R4.2, U2.38 (PA15)
LED_RGB_RED: R2.2, U2.10 (PA0)
NRST: C1.2, SW1.2, U2.7 (NRST)
unnamed: D1.1 (K), R3.1
unnamed: D2.3 (BK), R5.1
unnamed: D2.4 (GK), R4.1
unnamed: D2.1 (RK), R2.1
unnamed: D3.1 (K), R6.1
unnamed: JP3.2 (B), R13.2
unnamed: R1.2, SW2.2 (B)
RCC_OSC_IN: C9.2, U2.5 (PD0), Y1.1
RCC_OSC_OUT: C10.2, U2.6 (PD1), Y1.3
SPI_CLK: U2.15 (PA5), U3.6 (CLK); also elsewhere on the board
SPI_MISO: U2.16 (PA6), U3.2 (DO(IO1)); also elsewhere on the board
SPI_MOSI: U2.17 (PA7), U3.5 (DI(IO0)); also elsewhere on the board
SYS_JTCK-SWCLK: TP6.1, U2.37 (PA14)
SYS_JTDO-SWO: TP5.1, U2.39 (PB3)
SYS_JTMS-SWDIO: TP7.1, U2.34 (PA13)
UART1_RX: U2.43 (PB7); also elsewhere on the board
UART1_TX: U2.42 (PB6); also elsewhere on the board
USB_D+: R7.2, U2.33 (PA12); also elsewhere on the board
USB_D-: U2.32 (PA11); also elsewhere on the board
VBUS_DETECT: U2.20 (PB2); also elsewhere on the board
VDD_3V3: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C11.2, C12.2, D1.2 (A), D2.2 (A), D3.2 (A), R7.1, R8.2, R9.2, R10.2, R11.2, R12.2, SW2.3 (C), U1.3 (VCC), U2.1 (VBAT), U2.9 (VDDA), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U3.7 (IO3), U3.8 (VCC); also elsewhere on the board

Notes on the sheet:
VDD
Decoupling caps
Reset
CAN
VDDA
BOOT0
LED
Flash memory
HSE
Address selection
VBAT

Parts:
C20: 100n; C_0603_1608Metric
D8: PMEG2020EH; D_SOD-123F
J1, J2: 532610671; Molex_PicoBlade_53261-0671_1x06-1MP_P1.25mm_Horizontal
J3: USB_B_Micro; U-F-M5DD-W-2-SUS
J4: 530470310; Molex_PicoBlade_53261-0371_1x03-1MP_P1.25mm_Horizontal
R14, R15: 10k; R_0603_1608Metric
U7: USBLC6-2SC6; SOT-23-6

Connections:
/Connectors/usb_conn_d+: J3.3 (D+), U7.6 (I/O1)
/Connectors/usb_conn_d-: J3.2 (D-), U7.4 (I/O2)
CAN_+: J1.4, J2.4; also elsewhere on the board
CAN_-: J1.3, J2.3; also elsewhere on the board
GND: C20.2, J1.5, J1.6, J1.MP, J2.5, J2.6, J2.MP, J3.5 (GND), J3.6 (Shield), J4.1, J4.MP, R15.2, U7.2 (GND); also elsewhere on the board
unnamed: D8.1 (K), J4.2
UART1_RX: J4.3; also elsewhere on the board
UART1_TX: D8.2 (A); also elsewhere on the board
USB_D+: U7.1 (I/O1); also elsewhere on the board
USB_D-: U7.3 (I/O2); also elsewhere on the board
VBUS_DETECT: R14.2, R15.1; also elsewhere on the board
VDD_5V_USB: C20.1, J3.1 (VBUS), R14.1, U7.5 (VBUS); also elsewhere on the board
VDD_7V0: J1.1, J1.2, J2.1, J2.2; also elsewhere on the board

Notes on the sheet:
UART
USB

Parts:
C21: 10n; C_0603_1608Metric
C22, C26: 1u; C_0603_1608Metric
C23, C24: 100n; C_0603_1608Metric
C25: 10u; C_0603_1608Metric
D6, D7: BZX84-C3V3; SOT-23
J5: 532610271; Molex_PicoBlade_53261-0271_1x02-1MP_P1.25mm_Horizontal
L1: 27n; L_0603_1608Metric
R16, R20, R21: 1k; R_0603_1608Metric
R17: 330; R_0603_1608Metric
R18: 100k; R_0603_1608Metric
R19: 470; R_0603_1608Metric
R22: 10k; R_0603_1608Metric
RV1: 3224W-1-103E; Potentiometer_Bourns_3224W_Vertical
TP1, TP2, TP3: Signal; TestPoint_Bridge_Pitch2.54mm_Drill1.0mm
TP4: GND; TestPoint_Bridge_Pitch6.35mm_Drill1.3mm
U8: TL072; SO-8_3.9x4.9mm_P1.27mm
U9: ADS1120-PW; TSSOP-16_4.4x5mm_P0.65mm

Connections:
ADC_CS: U9.2 (~CS); also elsewhere on the board
ADC_DRDY: U9.14 (~DRDY); also elsewhere on the board
GND: C21.1, C22.1, C23.1, C24.2, C26.1, D7.1 (A), J5.1, J5.MP, R17.2, R22.1, TP4.1, U8.5 (+), U9.3 (CLK), U9.4 (DGND), U9.5 (AVSS); also elsewhere on the board
unnamed: C25.2, R19.1, R22.2
unnamed: C26.2, R19.2, RV1.1, TP3.1
unnamed: D6.1 (A), D7.3 (K), R18.2, TP1.1, U9.11 (AIN0/REFP1)
unnamed: C25.1, J5.2, TP2.1
unnamed: R18.1, R21.2, U8.1
unnamed: R20.1, RV1.3, U8.7
unnamed: R16.1, R17.1, U8.3 (+)
unnamed: R20.2, R21.1, U8.2 (-)
unnamed: RV1.2, U8.6 (-)
unnamed: C21.2, C22.2, C23.2, L1.1, U9.12 (AVDD)
SPI_CLK: U9.1 (SCLK); also elsewhere on the board
SPI_MISO: U9.15 (DOUT/~DRDY); also elsewhere on the board
SPI_MOSI: U9.16 (DIN); also elsewhere on the board
VDD_3V3: C24.1, D6.3 (K), L1.2, R16.2, U9.13 (DVDD); also elsewhere on the board
VDD_5V0: U8.8 (V+); also elsewhere on the board
VDD_-5V0: U8.4 (V-); also elsewhere on the board

Notes on the sheet:
VDDA
<-INT
BZX84C3V3

Parts:
C13, C17: 330n; C_0603_1608Metric
C14, C18: 100n; C_0603_1608Metric
C15, C16: 1u; C_0603_1608Metric
C19: 10n; C_0603_1608Metric
D4, D5: PMEG2020EH; D_SOD-123F
U4: L78L05_SOT89; SOT-89-3
U5: LD3985M33R_SOT23; SOT-23-5
U6: L79L05_SOT89; SOT-89-3

Connections:
GND: C13.1, C14.1, C15.2, C16.2, C17.2, C18.2, C19.2, U4.2 (GND), U5.2 (GND), U6.1 (GND); also elsewhere on the board
unnamed: C15.1, D4.1 (K), D5.1 (K), U5.1 (VIN), U5.3 (INH)
unnamed: C19.1, U5.4 (BYP)
VDD_3V3: C16.1, U5.5 (VOUT); also elsewhere on the board
VDD_5V0: C18.1, U4.1 (OUT); also elsewhere on the board
VDD_5V_USB: D5.2 (A); also elsewhere on the board
VDD_7V0: C13.2, C17.1, D4.2 (A), U4.3 (IN), U6.2 (VI); also elsewhere on the board
VDD_-5V0: C14.2, U6.3 (VO); also elsewhere on the board

Notes on the sheet:
OUT: 3.3V 150mA
OUT: -5V 100mA
OUT: 5V 100mA
INH: >1.2V ON <0.4V OFF

Board: 4 copper layers, 38.3 x 25.1 mm, 90 parts (49 on the bottom side), 59 nets.

## KiCad design Hardware/ciam/impeller/rpi_power_shield/power_sheld.kicad_pcb

Board: 2 copper layers, 65.0 x 56.0 mm, 54 parts (15 on the bottom side), 27 nets.

Parts:
C1, C2, C12: 10u; CP_Radial_D10.0mm_P5.00mm
C3, C4, C6, C7: 330p; C_1206_3216Metric
C5: 220u; CP_Radial_D10.0mm_P5.00mm
C8, C10, C11, C14: 100n; C_1206_3216Metric
C9: 22u; CP_EIA-7343-31_Kemet-D
C13: 1u; C_1206_3216Metric
C15: 100u; CP_Radial_D6.3mm_P2.50mm
C16: 4u7; C_0805_2012Metric
C17, C18: 100n; C_0805_2012Metric
C19: 10u; C_0805_2012Metric
D1, D2: SS54C; D_SMC
D3, D4: FYLS-1206SRC; D_1206_3216Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5_Pad_Via
J1, J3: Micro-fit_1x2P; Molex_Micro-Fit_3.0_43045-0200_2x01_P3.00mm_Horizontal
J2: RPi; PinSocket_2x20_P2.54mm_Vertical
J4: Micro-Fit_2x2P; Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal
K1: NRP-12-C-05D-H
L1: B82721-K2222-U30
Q1, Q2: BSS138; SOT-23
R1, R2: R_reg; R_0603_1608Metric
R3, R4, R9, R10: 10k; R_0805_2012Metric
R5: 1k5; R_0603_1608Metric
R6: 2k; R_0603_1608Metric
R7, R8, R12: 360; R_0603_1608Metric
R11: 220; R_0603_1608Metric
TP1, TP2: TestPoint; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
U1: VDV8-1E05
U2: L4940V5; TO-220-3_Horizontal_TabDown
U3: B0505MT-1WR4
U4, U5: HCPL-0600; SO-8_3.9x4.9mm_P1.27mm

Connections:
5V0_SENS: C5.1, C7.1, D1.2 (A), D3.2 (A), R1.1, R5.2, U1.14 (+VOUT)
/5V_ISO: C18.1, C19.1, R12.2, U3.8 (+Vo), U4.7 (VE), U4.8 (VCC)
/BATT_7.4_IN: C8.1, J3.2, TP1.1, U2.1 (IN)
/GND_9-70_IN: C2.2, J1.1, L1.2
/GND_UART_ISO: C18.2, C19.2, J4.1 (Pin_2), J4.4, U3.6 (0V), U3.7 (0V), U4.5 (GND)
/VDD_9-70_IN: C2.1, J1.2, L1.1
GND: C5.2, C6.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C16.2, C17.2, J2.6, J2.9, J2.14, J2.20, J2.25, J2.30, J2.34, J2.39, J3.1, Q1.2 (S), R2.2, R4.1, R6.2, R7.1, R8.1, TP2.1, U1.16 (-VOUT), U2.2 (GND), U3.1 (gnd), U3.2 (gnd), U5.5 (GND)
unnamed: C1.1, C3.1, L1.4, U1.22 (+VIN), U1.23 (+VIN)
unnamed: C1.2, C4.1, L1.3, U1.2 (-VIN), U1.3 (-VIN)
unnamed: D2.2 (A), D4.2 (A), K1.1
unnamed: D3.1 (K), R8.2
unnamed: D4.1 (K), R7.2
unnamed: J2.33, R5.1, R6.1
unnamed: J2.37, Q1.1 (G), R4.2
unnamed: J4.2 (Pin_1), U4.6 (VOut)
unnamed: J4.3, U5.3 (Cathode)
unnamed: Q2.3 (D), R10.2, U5.6 (VOut)
unnamed: R1.2, R2.1, U1.15 (REG)
unnamed: C3.2, C4.2, C6.2, C7.2, U1.24 (SHIELD)
unnamed: C9.1, C10.1, K1.3, U2.3 (OUT)
unnamed: R11.2, U4.2 (Anode)
unnamed: R12.1, U5.2 (Anode)
RELAY_SIG: K1.2, Q1.3 (D), R3.2
UART_RX: J2.10, Q2.2 (S), R9.2
UART_TX: J2.8, U4.3 (Cathode)
VDD_3V3: C14.2, J2.1, Q2.1 (G), R9.1, R11.1
VDD_5V0: C11.1, C12.1, C13.1, C15.1, C16.1, C17.1, D1.1 (K), D2.1 (K), J2.2, J2.4, K1.5, R3.1, R10.1, U3.13 (Vin), U3.14 (Vin), U5.7 (VE), U5.8 (VCC)

File Hardware/ciam/impeller/rpi_power_shield/BOM_RPi_Shield_PCB.xlsx:

Reference | Value | Footprint | Ссылка | Цена | Человекопонятное название | Кол. | Кол-во с запасом | Сумма
C1, C2, C12 | 10u |  | https://www.chipdip.ru/product0/9000383642 | 30 | Конденсатор электролитический | 3 | 9 | 270
C3, C4, C6, C7 | 330p |  | https://www.chipdip.ru/product/grm31a7u2j331jw31d | 25 | Керамический конденсатор | 4 | 12 | 300
C5 | 220u |  | https://www.chipdip.ru/product0/9000239379 | 52 | Конденсатор электролитический | 1 | 3 | 156
C8, C10, C11, C14 | 100n |  | https://www.chipdip.ru/product/grm319r71h104k | 13 | Конденсатор керамический | 4 | 12 | 156
C9 | 22u |  | https://www.chipdip.ru/product/tecap-22-mkf-20-v-tip-d-10 | 36 | Конденсатор электролитический | 1 | 3 | 108
C13 | 1u |  | https://www.chipdip.ru/product/grm31mr71e105k | 25 | Конденсатор керамический | 1 | 3 | 75
C15 | 100u |  | https://www.chipdip.ru/product0/14560 | 13 | Конденсатор электролитический | 1 | 3 | 39
D1, D2 | SS54C |  | https://www.chipdip.ru/product/ss54c | 14 | Диод Шоттки | 2 | 6 | 84
D3, D4 | FYLS-1206SRC | Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder | https://www.chipdip.ru/product0/8002031702 | 38 | Светодиод красный | 2 | 6 | 228
J1, J3 | Micro-fit_1x2P |  | https://www.chipdip.ru/product/sct3001wr-2x01p | 29 | Коннектор micro-fit | 2 | 6 | 174
J2 | RPi |  | https://www.chipdip.ru/product/pbd-40 | 29 | Разъем штыревой 2x20 | 1 | 3 | 87
K1 | NRP-12-C-05D-H |  | https://www.chipdip.ru/product/nrp-12-c-05d-h | 260 | электромех. реле | 1 | 3 | 780
L1 | B82721-K2222-U30 |  | https://www.chipdip.ru/product/b82721-k2222-u30-2x1000 | 380 | Дроссель подавления ЭМП | 1 | 3 | 1140
Q1 | BSS138 | Package_TO_SOT_SMD:SOT-23 | https://www.chipdip.ru/product/bss138-umw | 3 | Транзистор полевой n типа | 1 | 3 | 9
R1, R2 | R_reg | Resistor_SMD:R_0603_1608Metric |  |  |  | 2 | 6 | 0
R3, R4 | 10k | Resistor_SMD:R_0805_2012Metric | https://www.chipdip.ru/product/0.125w-0805-10-kom-5 | 5 | Резистор 10k Ом | 2 | 6 | 30
R5 | 1k5 | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-1.5-kom-1 | 5 | Резистор 1К ОМ | 1 | 3 | 15
R6 | 2k | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-2-kom-1 | 5 | Резистор 2К ОМ | 1 | 3 | 15
R7, R8 | 360 | Resistor_SMD:R_0603_1608Metric | https://www.chipdip.ru/product/0.1w-0603-360-om-1 | 5 | Резистор 360 Ом | 2 | 6 | 30
U1 | VDV8-1E05 |  | https://www.chipdip.ru/product0/8010397463 | 8260 | DC-DC преобразователь 24->5В | 1 | 3 | 24780
U2 | L4940V5 |  | https://www.chipdip.ru/product/l4940v5 | 200 | LDO регулятор | 1 | 3 | 600
 |  |  |  |  |  |  |  | СУММА
 |  |  |  |  |  |  |  | 29076
