# Repository AeroKITties/Kitties-Hardware (continued)

## KiCad design Hardware/ciam/impeller18/impeller18.kicad_pcb (continued)

Parts:
C76, C79, C80, C83: 100n; C_0603_1608Metric
C77, C78, C81, C82: 10u; C_0603_1608Metric
D14, D15: FYLS-0603BUGC; LED_0603_1608Metric
J8, J9, J10: 430451800
Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22: BSS138; SOT-23
R2, R3, R7, R8, R46, R48, R54, R56, R62, R64, R70, R72, R78, R80, R86, R88, R94, R96, R102, R104, R110, R112, R288, R292, R293, R294, R295, R296, R297, R298, R299, R300, R301, R302, R303, R304: 10k; R_0603_1608Metric
R41, R42, R49, R50, R57, R58, R65, R66, R73, R74, R81, R82, R89, R90, R97, R98, R105, R106: 1M; R_0603_1608Metric
R43, R44, R51, R52, R59, R60, R67, R68, R75, R76, R83, R84, R91, R92, R99, R100, R107, R108: 360k; R_0603_1608Metric
R45, R47, R53, R55, R61, R63, R69, R71, R77, R79, R85, R87, R93, R95, R101, R103, R109, R111, R113, R114: 360; R_0603_1608Metric
TP17, TP18, TP23, TP24: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
U19, U20, U21, U22: TLP291-4; SOIC-16_4.55x10.3mm_P1.27mm
U23, U24: TLP291
U25, U26: B0505MT-1WR4

Connections:
3V3: R46.2, R48.2, R54.2, R56.2, R62.2, R64.2, R70.2, R72.2, R78.2, R80.2, R86.2, R88.2, R94.2, R96.2, R102.2, R104.2, R110.2, R112.2; also elsewhere on the board
5V0: C78.1, C79.1, C82.1, C83.1, U25.13 (Vin), U25.14 (Vin), U26.13 (Vin), U26.14 (Vin); also elsewhere on the board
5V0_SWITCHES_1: C76.1, C77.1, R2.1, R3.1, R7.1, R8.1, R113.2, R288.1, R292.1, R293.1, R294.1, R295.1, TP17.1, U19.1, U19.3, U19.5, U19.7, U21.1, U21.3, U21.5, U21.7, U23.1, U25.8 (+Vo)
5V0_SWITCHES_2: C80.1, C81.1, R114.2, R296.1, R297.1, R298.1, R299.1, R300.1, R301.1, R302.1, R303.1, R304.1, TP23.1, U20.1, U20.3, U20.5, U20.7, U22.1, U22.3, U22.5, U22.7, U24.1, U26.8 (+Vo)
/Switches_1/SWITCH_1.1_EXT: J8.1, J9.1, R41.2
/Switches_1/SWITCH_1.2_EXT: J8.3, J9.3, R49.2
/Switches_1/SWITCH_1.3_EXT: J8.5, J9.5, R57.2
/Switches_1/SWITCH_1.4_EXT: J8.7, J9.7, R65.2
/Switches_1/SWITCH_1.5_EXT: J8.9, J9.9, R73.2
/Switches_1/SWITCH_1.6_EXT: J8.11, J9.11, R81.2
/Switches_1/SWITCH_1.7_EXT: J8.13, J9.13, R89.2
/Switches_1/SWITCH_1.8_EXT: J8.15, J9.15, R97.2
/Switches_1/SWITCH_1.9_EXT: J8.17, J9.17, R105.2
/Switches_1/SWITCH_2.1_EXT: J9.2, J10.1, R42.2
/Switches_1/SWITCH_2.2_EXT: J9.4, J10.3, R50.2
/Switches_1/SWITCH_2.3_EXT: J9.6, J10.5, R58.2
/Switches_1/SWITCH_2.4_EXT: J9.8, J10.7, R66.2
/Switches_1/SWITCH_2.5_EXT: J9.10, J10.9, R74.2
/Switches_1/SWITCH_2.6_EXT: J9.12, J10.11, R82.2
/Switches_1/SWITCH_2.7_EXT: J9.14, J10.13, R90.2
/Switches_1/SWITCH_2.8_EXT: J9.16, J10.15, R98.2
/Switches_1/SWITCH_2.9_EXT: J9.18, J10.17, R106.2
GND: C78.2, C79.2, C82.2, C83.2, U19.9, U19.11, U19.13, U19.15, U20.9, U20.11, U20.13, U20.15, U21.9, U21.11, U21.13, U21.15, U22.9, U22.11, U22.13, U22.15, U23.3, U24.3, U25.1 (gnd), U25.2 (gnd), U26.1 (gnd), U26.2 (gnd); also elsewhere on the board
GND_IN: C76.2, C77.2, C80.2, C81.2, D14.1 (K), D15.1 (K), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), Q11.2 (S), Q12.2 (S), Q13.2 (S), Q14.2 (S), Q15.2 (S), Q16.2 (S), Q17.2 (S), Q18.2 (S), Q19.2 (S), Q20.2 (S), Q21.2 (S), Q22.2 (S), R43.1, R44.1, R51.1, R52.1, R59.1, R60.1, R67.1, R68.1, R75.1, R76.1, R83.1, R84.1, R91.1, R92.1, R99.1, R100.1, R107.1, R108.1, TP18.1, TP24.1, U25.6 (0V), U25.7 (0V), U26.6 (0V), U26.7 (0V); also elsewhere on the board
unnamed: D14.2 (A), R113.1
unnamed: D15.2 (A), R114.1
unnamed: Q5.3 (D), R3.2, R45.1
unnamed: Q5.1 (G), R41.1, R43.2
unnamed: Q6.3 (D), R47.1, R297.2
unnamed: Q6.1 (G), R42.1, R44.2
unnamed: Q7.3 (D), R2.2, R53.1
unnamed: Q7.1 (G), R49.1, R51.2
unnamed: Q8.3 (D), R55.1, R296.2
unnamed: Q8.1 (G), R50.1, R52.2
unnamed: Q9.3 (D), R7.2, R61.1
unnamed: Q9.1 (G), R57.1, R59.2
unnamed: Q10.3 (D), R63.1, R298.2
unnamed: Q10.1 (G), R58.1, R60.2
unnamed: Q11.3 (D), R8.2, R69.1
unnamed: Q11.1 (G), R65.1, R67.2
unnamed: Q12.3 (D), R71.1, R299.2
unnamed: Q12.1 (G), R66.1, R68.2
unnamed: Q13.3 (D), R77.1, R288.2
unnamed: Q13.1 (G), R73.1, R75.2
unnamed: Q14.3 (D), R79.1, R300.2
unnamed: Q14.1 (G), R74.1, R76.2
unnamed: Q15.3 (D), R85.1, R292.2
unnamed: Q15.1 (G), R81.1, R83.2
unnamed: Q16.3 (D), R87.1, R301.2
unnamed: Q16.1 (G), R82.1, R84.2
unnamed: Q17.3 (D), R93.1, R293.2
unnamed: Q17.1 (G), R89.1, R91.2
unnamed: Q18.3 (D), R95.1, R302.2
unnamed: Q18.1 (G), R90.1, R92.2
unnamed: Q19.3 (D), R101.1, R294.2
unnamed: Q19.1 (G), R97.1, R99.2
unnamed: Q20.3 (D), R103.1, R303.2
unnamed: Q20.1 (G), R98.1, R100.2
unnamed: Q21.3 (D), R109.1, R295.2
unnamed: Q21.1 (G), R105.1, R107.2
unnamed: Q22.3 (D), R111.1, R304.2
unnamed: Q22.1 (G), R106.1, R108.2
unnamed: R45.2, U19.2
unnamed: R47.2, U20.2
unnamed: R53.2, U19.4
unnamed: R55.2, U20.4
unnamed: R61.2, U19.6
unnamed: R63.2, U20.6
unnamed: R69.2, U19.8
unnamed: R71.2, U20.8
unnamed: R77.2, U21.2
unnamed: R79.2, U22.2
unnamed: R85.2, U21.4
unnamed: R87.2, U22.4
unnamed: R93.2, U21.6
unnamed: R95.2, U22.6
unnamed: R101.2, U21.8
unnamed: R103.2, U22.8
unnamed: R109.2, U23.2
unnamed: R111.2, U24.2
SWITCH_1.1_3V3: R46.1, U19.16
SWITCH_1.2_3V3: R54.1, U19.14
SWITCH_1.3_3V3: R62.1, U19.12
SWITCH_1.4_3V3: R70.1, U19.10
SWITCH_1.5_3V3: R78.1, U21.16
SWITCH_1.6_3V3: R86.1, U21.14
SWITCH_1.7_3V3: R94.1, U21.12
SWITCH_1.8_3V3: R102.1, U21.10
SWITCH_1.9_3V3: R110.1, U23.4
SWITCH_2.1_3V3: R48.1, U20.16
SWITCH_2.2_3V3: R56.1, U20.14
SWITCH_2.3_3V3: R64.1, U20.12
SWITCH_2.4_3V3: R72.1, U20.10
SWITCH_2.5_3V3: R80.1, U22.16
SWITCH_2.6_3V3: R88.1, U22.14
SWITCH_2.7_3V3: R96.1, U22.12
SWITCH_2.8_3V3: R104.1, U22.10
SWITCH_2.9_3V3: R112.1, U24.4
VIN: J8.2, J8.4, J8.6, J8.8, J8.10, J8.12, J8.14, J8.16, J8.18, J10.2, J10.4, J10.6, J10.8, J10.10, J10.12, J10.14, J10.16, J10.18; also elsewhere on the board

Notes on the sheet:
16.2 м
0.5 м
0.9 м
9 м
41.4 м

Parts:
C96, C99, C105, C107: 100n; C_0603_1608Metric
C97, C98: 10u; C_0603_1608Metric
C104: 10n; C_0603_1608Metric
C106: 1u; C_0603_1608Metric
D20: FYLS-0603BUGC; LED_0603_1608Metric
J19: 430450600
L4: 27n; C_0603_1608Metric
Q37, Q38: BSS138; SOT-23
R222, R239, R242: 360; R_0603_1608Metric
R223, R224, R226, R230, R231, R233, R235, R237, R238, R240, R241: 10k; R_0603_1608Metric
R225, R229, R234: 180; R_0603_1608Metric
TP29, TP30: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
U65: B0505MT-1WR4
U66: HCPL-0600; SO-8_3.9x4.9mm_P1.27mm
U67, U70: HCPL-0630; SOIC-8_3.9x4.9mm_P1.27mm
U68: ADS1120-PW; TSSOP-16_4.4x5mm_P0.65mm
U69: IP4220; SOT-23-6

Connections:
3V3: Q37.1 (G), Q38.1 (G), R225.2, R226.1, R229.2, R230.1, R234.2, R235.1, R238.1, R241.1; also elsewhere on the board
5V0: C98.1, C99.1, R237.1, R240.1, U65.13 (Vin), U65.14 (Vin), U70.8 (VCC); also elsewhere on the board
/ADC_RUD/ADC_RUD_5V_1: J19.3, U68.11 (AIN0/REFP1), U69.1 (IO1)
/ADC_RUD/ADC_RUD_5V_2: J19.4, U68.10 (AIN1), U69.3 (IO2)
/ADC_RUD/SPI_ADC_RUD_CLK: R224.1, U66.6 (VO), U68.1 (SCLK)
/ADC_RUD/SPI_ADC_RUD_CS: R233.1, U67.6 (VO2), U68.2 (~CS)
/ADC_RUD/SPI_ADC_RUD_MOSI: R231.2, U67.7 (VO1), U68.16 (DIN)
ADC_RUD_INT: C96.1, C97.1, C107.1, J19.1, J19.2, L4.2, Q38.2 (S), R222.2, R223.1, R224.2, R231.1, R233.2, R239.2, R241.2, R242.2, TP29.1, U65.8 (+Vo), U66.8 (VCC), U67.8 (VCC), U68.13 (DVDD), U68.14 (~DRDY), U68.15 (DOUT/~DRDY), U69.5 (VDD), U70.2 (C1), U70.3 (C2)
GND: C98.2, C99.2, C104.1, C105.1, C106.1, C107.2, U65.1 (gnd), U65.2 (gnd), U70.5 (GND); also elsewhere on the board
GND_ADC_RUD: C96.2, C97.2, D20.1 (K), J19.5, J19.6, TP30.1, U65.6 (0V), U65.7 (0V), U66.5 (GND), U67.5 (GND), U68.3 (CLK), U68.4 (DGND), U68.5 (AVSS), U69.2 (GND)
unnamed: D20.2 (A), R222.1
unnamed: Q37.3 (D), R237.2, U70.7 (VO1)
unnamed: Q38.3 (D), R240.2, U70.6 (VO2)
unnamed: R225.1, U66.2 (A)
unnamed: R223.2, U66.7 (EN)
unnamed: R229.1, U67.1 (A1)
unnamed: R234.1, U67.4 (A2)
unnamed: C104.2, C105.2, C106.2, L4.1, U68.12 (AVDD)
unnamed: R239.1, U70.1 (A1)
unnamed: R242.1, U70.4 (A2)
SPI1_STM32_ADC8_CS: R235.2, U67.3 (C2); also elsewhere on the board
SPI1_STM32_CLK: R226.2, U66.3 (C); also elsewhere on the board
SPI1_STM32_MISO: Q37.2 (S), R238.2; also elsewhere on the board
SPI1_STM32_MOSI: R230.2, U67.2 (C1); also elsewhere on the board

Notes on the sheet:
VDDA
вопросы к работе этой части

Parts:
C47, C48, C51, C52, C60, C61, C64, C65: 1u; C_0603_1608Metric
C49, C50, C53, C56, C59, C62, C63, C66, C69, C72: 100n; C_0603_1608Metric
C54, C55, C67, C68: 22p; C_0603_1608Metric
C57, C58, C70, C71: 10u; C_0603_1608Metric
D8, D10: PESD1CAN; SOT-23
D9, D11: FYLS-0603BUGC; LED_0603_1608Metric
J5, J6: 430450400; 430454000
J24, J25: PLS-5; PinHeader_1x05_P2.54mm_Vertical
L2, L3: B82790C0513N201
R27, R31: 120; R_0603_1608Metric
R28, R32: 0; R_0603_1608Metric
R29, R33: 10k; R_0603_1608Metric
R30, R34: 360; R_0603_1608Metric
SW4, SW5: MSS-12D16
TP3, TP4, TP5, TP6, TP15, TP16, TP19, TP20, TP37, TP38: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
U11, U12, U15, U16: ISO1050DUB
U13, U17: MCP2515-I/SO; SOIC-18W_7.5x11.6mm_P1.27mm
U14, U18: B0505MT-1WR4
Y3, Y4: X322516MLB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
3V3: C48.1, C49.1, C50.1, C52.1, C53.1, C61.1, C62.1, C63.1, C65.1, C66.1, R29.1, R33.1, U11.1 (VCC1), U12.1 (VCC1), U13.18 (VDD), U15.1 (VCC1), U16.1 (VCC1), U17.18 (VDD); also elsewhere on the board
5V0: C58.1, C59.1, C71.1, C72.1, U14.13 (Vin), U14.14 (Vin), U18.13 (Vin), U18.14 (Vin); also elsewhere on the board
5V0_CAN0: C47.1, C51.1, C56.1, C57.1, R30.2, TP15.1, U11.8 (VCC2), U12.8 (VCC2), U14.8 (+Vo)
5V0_CAN1: C60.1, C64.1, C69.1, C70.1, R34.2, TP19.1, U15.8 (VCC2), U16.8 (VCC2), U18.8 (+Vo)
/CAN/CAN0+: D8.1, J5.4, L2.3
/CAN/CAN0-: D8.2, J5.2, L2.2
/CAN/CAN0_+: L2.4, SW4.1 (A), TP4.1, U11.7 (CANH), U12.7 (CANH)
/CAN/CAN0_-: L2.1, R27.1, TP3.1, U11.6 (CANL), U12.6 (CANL)
/CAN/CAN0_RPi_RX: J24.1, U12.2 (RXD), U13.2 (RXCAN)
/CAN/CAN0_RPi_TX: J24.2, U12.3 (TXD), U13.1 (TXCAN)
/CAN/CAN1+: D10.1, J6.4, L3.3
/CAN/CAN1-: D10.2, J6.2, L3.2
/CAN/CAN1_+: L3.4, SW5.1 (A), TP6.1, U15.7 (CANH), U16.7 (CANH)
/CAN/CAN1_-: L3.1, R31.1, TP5.1, U15.6 (CANL), U16.6 (CANL)
/CAN/CAN1_RPi_RX: J25.1, U16.2 (RXD), U17.2 (RXCAN)
/CAN/CAN1_RPi_TX: J25.2, U16.3 (TXD), U17.1 (TXCAN)
CAN0_RPI_INT: U13.12 (~INT); also elsewhere on the board
CAN0_STM32_RX: J24.3, U11.2 (RXD)
CAN0_STM32_TX: J24.4, U11.3 (TXD)
CAN1_RPI_INT: U17.12 (~INT); also elsewhere on the board
CAN1_STM32_RX: J25.3, U15.2 (RXD)
CAN1_STM32_TX: J25.4, U15.3 (TXD)
GND: C48.2, C49.2, C50.2, C52.2, C53.2, C54.1, C55.1, C58.2, C59.2, C61.2, C62.2, C63.2, C65.2, C66.2, C67.1, C68.1, C71.2, C72.2, U11.4 (GND1), U12.4 (GND1), U13.9 (VSS), U14.1 (gnd), U14.2 (gnd), U15.4 (GND1), U16.4 (GND1), U17.9 (VSS), U18.1 (gnd), U18.2 (gnd), Y3.2, Y3.4, Y4.2, Y4.4; also elsewhere on the board
GND_CAN0: C47.2, C51.2, C56.2, C57.2, D8.3, D9.1 (K), J5.1, J5.3, J24.5, TP16.1, U11.5 (GND2), U12.5 (GND2), U14.6 (0V), U14.7 (0V)
GND_CAN1: C60.2, C64.2, C69.2, C70.2, D10.3, D11.1 (K), J6.1, J6.3, J25.5, TP20.1, U15.5 (GND2), U16.5 (GND2), U18.6 (0V), U18.7 (0V)
unnamed: C55.2, R28.1, Y3.3
unnamed: C68.2, R32.1, Y4.3
unnamed: D9.2 (A), R30.1
unnamed: D11.2 (A), R34.1
unnamed: R27.2, SW4.2 (B)
unnamed: R31.2, SW5.2 (B)
unnamed: R28.2, U13.8 (OSC1)
unnamed: C54.2, TP37.1, U13.7 (OSC2), Y3.1
unnamed: R29.2, U13.17 (~RESET)
unnamed: R32.2, U17.8 (OSC1)
unnamed: C67.2, TP38.1, U17.7 (OSC2), Y4.1
unnamed: R33.2, U17.17 (~RESET)
SPI1_RPi_CAN0_CS: U13.16 (~CS); also elsewhere on the board
SPI1_RPi_CAN1_CS: U17.16 (~CS); also elsewhere on the board
SPI1_RPi_MISO: U13.15 (SO), U17.15 (SO); also elsewhere on the board
SPI1_RPi_MOSI: U13.14 (SI), U17.14 (SI); also elsewhere on the board
SPI1_RPi_SCK: U13.13 (SCK), U17.13 (SCK); also elsewhere on the board

Notes on the sheet:
https://files.waveshare.com/upload/1/15/2-CH-CAN-HAT-Schematic.pdf шилд
1.5 м

Parts:
C90, C93, C94, C95: 100n; C_0603_1608Metric
C91, C92: 10u; C_0603_1608Metric
D18: FYLS-0603BUGC; LED_0603_1608Metric
J18: 430451600
Q36: BSS138; SOT-23
R190: 360; R_0603_1608Metric
R191, R193, R199, R204, R209, R211, R217, R219: 1M; R_0603_1608Metric
R192, R195, R200, R206, R210, R215, R218, R220: 200k; R_0603_1608Metric
R194, R196, R198, R202, R203, R205, R208, R212, R213, R214: 10k; R_0603_1608Metric
R197, R201, R207: 180; R_0603_1608Metric
R216: 470; R_0603_1608Metric
TP27, TP28: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
U57: B0505MT-1WR4
U58, U62: HCPL-0600; SO-8_3.9x4.9mm_P1.27mm
U59: MCP3008; SOIC-16_3.9x9.9mm_P1.27mm
U60: HCPL-0630; SOIC-8_3.9x4.9mm_P1.27mm
U61, U63: IP4220; SOT-23-6

Connections:
3V3: Q36.1 (G), R197.2, R198.1, R201.2, R202.1, R207.2, R208.1, R214.1; also elsewhere on the board
5V0: C92.1, C93.1, R212.1, R213.1, U57.13 (Vin), U57.14 (Vin), U62.8 (VCC); also elsewhere on the board
5V0_ADC: C90.1, C91.1, C94.1, C95.1, R190.2, R194.1, R196.2, R203.1, R205.2, R216.1, TP27.1, U57.8 (+Vo), U58.8 (VCC), U59.15 (Vref), U59.16 (Vdd), U60.8 (VCC), U61.5 (VDD), U63.5 (VDD)
/ADC8/ADC_5V_1: R191.2, R192.2, U59.1 (CH0), U61.1 (IO1)
/ADC8/ADC_5V_2: R193.2, R195.2, U59.2 (CH1), U61.3 (IO2)
/ADC8/ADC_5V_3: R199.2, R200.2, U59.3 (CH2), U61.4 (IO3)
/ADC8/ADC_5V_4: R204.2, R206.2, U59.4 (CH3), U61.6 (IO4)
/ADC8/ADC_5V_5: R209.2, R210.2, U59.5 (CH4), U63.1 (IO1)
/ADC8/ADC_5V_6: R211.2, R215.2, U59.6 (CH5), U63.3 (IO2)
/ADC8/ADC_5V_7: R217.2, R218.2, U59.7 (CH6), U63.4 (IO3)
/ADC8/ADC_5V_8: R219.2, R220.2, U59.8 (CH7), U63.6 (IO4)
/ADC8/ADC_30V_1: R191.1
/ADC8/ADC_30V_2: R193.1
/ADC8/ADC_30V_3: R199.1
/ADC8/ADC_30V_4: R204.1
/ADC8/ADC_30V_5: R209.1
/ADC8/ADC_30V_6: R211.1
/ADC8/ADC_30V_7: R217.1
/ADC8/ADC_30V_8: R219.1
/ADC8/ADC_30V_IN_1: J18.1
/ADC8/ADC_30V_IN_2: J18.5
/ADC8/ADC_30V_IN_3: J18.3
/ADC8/ADC_30V_IN_4: J18.7
/ADC8/ADC_30V_IN_5: J18.9
/ADC8/ADC_30V_IN_6: J18.11
/ADC8/ADC_30V_IN_7: J18.13
/ADC8/ADC_30V_IN_8: J18.15
/ADC8/SPI_ADC8_CLK: R196.1, U58.6 (VO), U59.13 (CLK)
/ADC8/SPI_ADC8_CS: R205.1, U59.10 (~CS/SHDN), U60.6 (VO2)
/ADC8/SPI_ADC8_MISO: U59.12 (Dout), U62.3 (C)
/ADC8/SPI_ADC8_MOSI: R203.2, U59.11 (Din), U60.7 (VO1)
GND: C92.2, C93.2, U57.1 (gnd), U57.2 (gnd), U62.5 (GND); also elsewhere on the board
GND_ADC: C90.2, C91.2, C94.2, C95.2, D18.1 (K), J18.2, J18.4, J18.6, J18.8, J18.10, J18.12, J18.14, J18.16, R192.1, R195.1, R200.1, R206.1, R210.1, R215.1, R218.1, R220.1, TP28.1, U57.6 (0V), U57.7 (0V), U58.5 (GND), U59.9 (DGND), U59.14 (AGND), U60.5 (GND), U61.2 (GND), U63.2 (GND)
unnamed: D18.2 (A), R190.1
unnamed: Q36.3 (D), R213.2, U62.6 (VO)
unnamed: R197.1, U58.2 (A)
unnamed: R194.2, U58.7 (EN)
unnamed: R201.1, U60.1 (A1)
unnamed: R207.1, U60.4 (A2)
unnamed: R216.2, U62.2 (A)
unnamed: R212.2, U62.7 (EN)
SPI1_STM32_ADC8_CS: R208.2, U60.3 (C2); also elsewhere on the board
SPI1_STM32_CLK: R198.2, U58.3 (C); also elsewhere on the board
SPI1_STM32_MISO: Q36.2 (S), R214.2; also elsewhere on the board
SPI1_STM32_MOSI: R202.2, U60.2 (C1); also elsewhere on the board

Parts:
C111, C112, C114, C116: 100n; C_0603_1608Metric
C113: 1u; C_0603_1608Metric
C115: 4u7; C_0603_1608Metric
D25, D26: FYLS-0603BUGC; LED_0603_1608Metric
H9, H10, H11, H12: M4; MountingHole_4.3mm_M4_Pad_Via
J23: 430450415
R279, R280: 10k; R_0603_1608Metric
R281: 220; R_0603_1608Metric
R282: 470; R_0603_1608Metric
R283: 360; R_0603_1608Metric
TP33, TP34, TP35, TP36: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
U75: HCPL-0600; SO-8_3.9x4.9mm_P1.27mm
U76: LDL1117S50R; SOT-223-3_TabPin2
U77: SMU02M-12

Connections:
3V3: R281.1; also elsewhere on the board
5V0_FAN: C115.1, C116.1, R279.2, R280.2, R283.2, TP35.1, U75.8 (VCC), U76.2 (VO)
12V0: C111.1, U77.2 (+Vin); also elsewhere on the board
12V0_FAN: C112.1, C113.1, C114.1, J23.2, R282.2, TP33.1, U76.3 (VI), U77.4 (+Vout)
/Fan/FAN_PWM_5V0: J23.1, R280.1, U75.6 (VO)
FAN_PWM_3V3: U75.3 (C)
GND_12V: C111.2, U75.5 (GND), U77.1 (-Vin); also elsewhere on the board
GND_FAN: C112.2, C113.2, C114.2, C115.2, C116.2, D25.1 (K), D26.1 (K), J23.4, TP34.1, TP36.1, U76.1 (GND), U77.3 (-Vout)
unnamed: D25.2 (A), R282.1
unnamed: D26.2 (A), R283.1
unnamed: R281.2, U75.2 (A)
unnamed: R279.1, U75.7 (EN)
