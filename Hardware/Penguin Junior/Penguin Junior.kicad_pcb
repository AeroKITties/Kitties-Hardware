# Repository AeroKITties/Kitties-Hardware

## KiCad design Hardware/Penguin Junior/Penguin Junior.kicad_pcb

File Hardware/Penguin Junior/readme.md:

Файлы схемы платы(schematic): Penguin Junior.kicad_sch, Sensors.kicad_sch, Connectors.kicad_sch, OSD.kicad_sch, Power.kicad_sch

Файл трассировки платы(PCB): Penguin Junior.kicad_pcb

3D модель платы: Penguin Junior.SLDPRT

[Габариты и крепёжные отверстия полётного контроллера](Размеры.pdf)

[Файлы для производства(gerber)](gerber/gerber_1.1.zip)

[Файлы для сборки платы(расположение посадочных мест и компонентов)](bom/ibom.html)

[Файлы со списком компонентов для ПК(bom)](bom/bom.xlsx)

Board: 4 copper layers, 58.5 x 25.4 mm, 128 parts (55 on the bottom side), 102 nets.

Parts:
C1, C2, C3, C4, C5, C7, C9, C14, C15, C16, C17, C18, C19, C20, C23, C24, C25, C26, C27, C32: 100n; C_0402_1005Metric
C6, C34: 4u7; C_0402_1005Metric
C8, C33: 1u; C_0402_1005Metric
C10, C11: 8p; C_0402_1005Metric
C12, C13: 2u2; C_0402_1005Metric
C21, C22: 47; CP_EIA-3216-12_Kemet-S
C28: 10u; C_1210_3225Metric
C29: 100n; C_0805_2012Metric
C30: 100u; CP_Radial_D5.0mm_P2.00mm
C31: 150p; C_0402_1005Metric
D1, D2, D3: LED_MCU; LED_0603_1608Metric
D4, D6: PMEG2020EH; D_SOD-123F
D5: STPS3L60U; D_SMB
D7: LED_5V; LED_0603_1608Metric
D8: LED_SERVO; LED_0603_1608Metric
D9: LED_3V3; LED_0603_1608Metric
F1: MF-MSMF260-2; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
F2: MF-NSMF050-2; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_Pad_Via
J1: Conn_02x05_SWD; PinHeader_2x05_P1.27mm_Vertical
J2: Micro_SD_Card_Det1; TF01A-NEW
J3, J5: Conn_01x03_Video; Molex_PicoBlade_53047-0310_1x03_P1.25mm_Vertical
J4: USB_C; HCTL HC-TYPE-C-16P-01M
J6, J11: Conn_01x06_UART; Molex_PicoBlade_53047-0610_1x06_P1.25mm_Vertical
J7: Conn_01x04_I2C; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
J8, J9, J10: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J12: Conn_01x04_UART; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
J13: Conn_01x01; ContactPlatform_7.0x7.0
JP1, JP2, JP3, JP5, JP6: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
L1: 4u7; L_Sunlord_MWSA0503S
Q1: BSS138; SOT-23
R1: 10K; R_0603_1608Metric
R2: 3K; R_0603_1608Metric
R3: 75; R_0603_1608Metric
R4, R5: 330; R_0402_1005Metric
R6, R7: 4k7; R_0402_1005Metric
R8, R9, R10, R23, R24, R25, R28, R29, R30, R31, R32, R33, R34, R36, R37, R44, R45, R46: 220; R_0402_1005Metric
R11, R14: 75; R_0402_1005Metric
R12, R13, R15, R16, R17, R18, R19, R20, R21, R22, R41, R42: 10K; R_0402_1005Metric
R35: 0m2; R2725
R38: 47K; R_0402_1005Metric
SW1: SW_Push; button_small
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TestPointSignal; TestPoint_Pad_D1.0mm_low
U1: STM32F405RGTx; LQFP-64_10x10mm_P0.5mm
U2: BMI088; LGA-16_3x4.5x0.95mm
U3: BMP388; LGA-10_2x2x0.75mm
U4: MAX7456; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.85x5.4mm
U5: ST1S14PHR; TI_SO-PowerPAD-8
U6: INA219AxD; SOIC-8_3.9x4.9mm_P1.27mm
U7: LDL1117_3V3; SOT-223-3_TabPin2
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 27MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
3V3_JP: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C14.2, C15.1, C16.2, C17.1, C24.2, C32.1, C34.1, J2.4 (VDD), JP1.2 (B), JP4.2 (C), JP6.1 (A), Q1.1 (G), R6.2, R7.2, R8.2, R9.2, R10.2, R12.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.2, R46.1, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.3 (VDD), U2.11 (VDDIO), U3.1 (VDDIO), U3.10 (VDD), U6.5 (VS), U7.2 (VO)
5V0_JP: C18.1, C19.1, C20.1, D4.1 (K), D6.1 (K), D7.2 (A), F2.1, J6.1, J7.1, J11.1, J12.1, JP5.2 (B), R13.1, U4.3 (DVDD), U4.19 (RESET), U4.21 (AVDD), U4.24 (PVDD)
5V0_SERVO_JP: D6.2 (A), F1.1, JP2.1 (A), JP3.1 (A)
BOOT0: R22.1, U1.60 (BOOT0)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.2, C16.1, C17.2, C18.2, C19.2, C20.2, C24.1, C25.2, C28.1, C29.1, C30.2, C32.2, C33.2, C34.2, D5.2 (A), D8.1 (K), D9.1 (K), J1.3, J1.5, J1.9, J2.6 (VSS), J2.10 (SHIELD), J3.2, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J5.2, J6.6, J7.4, J9.1, J9.2, J9.3, J9.4, J9.5, J9.6, J9.7, J9.8, J9.9, J9.10, J11.6, J12.4, J13.1, R3.1, R4.1, R5.2, R14.1, R21.2, R41.2, R42.2, R44.1, SW1.1, U1.12 (VSSA), U1.18 (VSS), U1.63 (VSS), U2.2 (NC), U2.4 (GND), U2.6 (GNDIO), U2.7 (PS), U3.3 (VSS), U3.8 (VSS), U3.9 (VSS), U4.4 (DGND), U4.20 (AGND), U4.23 (PGND)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
I2C1_SCL: J7.2, J11.4, R7.1, U1.58 (PB6), U6.4 (SCL)
I2C1_SDA: J7.3, J11.5, R6.1, U1.59 (PB7), U6.3 (SDA)
INTERRUPTION1_ACCEL: U1.23 (PA7), U2.16 (INT1)
INTERRUPTION2_ACCEL: U1.28 (PB2), U2.1 (INT2)
INTERRUPTION3_GYRO: U1.9 (PC1), U2.12 (INT3)
INTERRUPTION4_GYRO: U1.8 (PC0), U2.13 (INT4)
LED_MCU_0: D1.1 (K), U1.2 (PC13)
LED_MCU_1: D2.1 (K), U1.3 (PC14)
LED_MCU_2: D3.1 (K), U1.4 (PC15)
NRST: C9.2, J1.10, SW1.2, U1.7 (NRST)
unnamed: C21.2, C22.2, R11.1
unnamed: D1.2 (A), R8.1
unnamed: D2.2 (A), R9.1
unnamed: D3.2 (A), R10.1
unnamed: C26.2, D5.1 (K), L1.1, U5.8 (SW)
unnamed: D7.1 (K), R44.2
unnamed: D8.2 (A), R45.2
unnamed: D9.2 (A), R46.2
unnamed: J1.1, JP6.2 (B)
unnamed: J3.1, J5.1, JP5.1 (A)
unnamed: J8.1, R23.2
unnamed: J8.2, R24.2
unnamed: J8.3, R25.2
unnamed: J8.4, R28.2
unnamed: J8.5, R29.2
unnamed: J8.6, R30.2
unnamed: J8.7, R31.2
unnamed: J8.8, R32.2
unnamed: J8.9, R33.2
unnamed: J8.10, R34.2
unnamed: JP1.1 (A), R21.1, R22.2
unnamed: JP4.1 (A), R42.1, U6.2 (A0)
unnamed: JP4.3 (B), R41.1, U6.1 (A1)
unnamed: Q1.3 (D), R13.2, U4.11 (SDOUT)
unnamed: R2.1, R3.2
unnamed: C12.2, U1.31 (VCAP_1)
unnamed: C13.2, U1.47 (VCAP_2)
unnamed: U4.5 (CLKIN), Y2.3
unnamed: C21.1, U4.25 (SAG)
unnamed: C23.1, U4.22 (VIN)
unnamed: C22.1, U4.26 (VOUT)
unnamed: U4.6 (XFB), Y2.1
unnamed: C26.1, U5.1 (BOOT)
unnamed: C31.1, R1.1, R2.2, U5.4 (FB)
unnamed: R38.1, U5.2 (PG)
unnamed: C27.1, R36.2, U6.8 (IN+)
unnamed: C27.2, R37.2, U6.7 (IN-)
RCC_OSC_IN: C10.2, TP7.1, U1.5 (PH0), Y1.1
RCC_OSC_OUT: C11.2, U1.6 (PH1), Y1.3
SDIO_CD: J2.9 (DET), R15.2, U1.41 (PA8)
SDIO_CK: J2.5 (CLK), U1.53 (PC12)
SDIO_CMD: J2.3 (CMD), R18.2, U1.54 (PD2)
SDIO_D0: J2.7 (DAT0), R17.2, U1.39 (PC8)
SDIO_D1: J2.8 (DAT1), R16.2, U1.40 (PC9)
SDIO_D2: J2.1 (DAT2), R20.1, U1.51 (PC10)
SDIO_D3: J2.2 (DAT3/CD), R19.2, U1.52 (PC11)
SPI1_BMI088_ACCEL_CS: TP6.1, U1.24 (PC4), U2.14 (CSB1)
SPI1_BMI088_GYRO_CS: TP5.1, U1.20 (PA4), U2.5 (CSB2)
SPI1_CLK: TP3.1, U1.21 (PA5), U2.8 (SCL/SCK), U3.2 (SCK)
SPI1_MISO: TP2.1, U1.56 (PB4), U2.10 (SDO2), U2.15 (SDO1), U3.5 (SDO)
SPI1_MOSI: TP1.1, U1.57 (PB5), U2.9 (SDA/SDI), U3.4 (SDI)
SPI1_MS5611_CS: TP4.1, U1.25 (PC5), U3.6 (CSB)
SPI2_MISO: Q1.2 (S), R12.2, U1.10 (PC2)
SPI2_MOSI: U1.11 (PC3), U4.9 (SDIN)
SPI2_OSD_CS: U1.33 (PB12), U4.8 (CS)
SPI2_SCK: U1.34 (PB13), U4.10 (SCLK)
SYS_JTCK-SWCLK: J1.4, U1.49 (PA14)
SYS_JTDO-SWO: J1.6, U1.55 (PB3)
SYS_JTMS-SWDIO: J1.2, U1.46 (PA13)
TM2_CH1/ADC2_EXTI15: R5.1, R24.1, U1.50 (PA15)
TM3_CH1: R29.1, U1.37 (PC6)
TM3_CH2: R28.1, U1.38 (PC7)
TM3_CH3: R33.1, U1.26 (PB0)
TM3_CH4: R32.1, U1.27 (PB1)
TM4_CH3: R30.1, U1.61 (PB8)
TM4_CH4: R31.1, U1.62 (PB9)
TM12_CH1: R25.1, U1.35 (PB14)
TM12_CH2/ADC1_EXTI15: R4.2, R23.1, U1.36 (PB15)
TM13_CH1: R34.1, U1.22 (PA6)
USART1_RX: J12.3, U1.43 (PA10)
USART1_TX: J12.2, U1.42 (PA9)
USART2_CTS: J6.4, U1.14 (PA0)
USART2_RTS: J6.5, U1.15 (PA1)
USART2_RX: J6.3, U1.17 (PA3)
USART2_TX: J6.2, U1.16 (PA2)
USART3_RX: J11.3, U1.30 (PB11)
USART3_TX: J11.2, U1.29 (PB10)
USB_OTG_FS_D+: J4.A6 (D+), J4.B6 (D+), U1.45 (PA12)
USB_OTG_FS_D-: J4.A7 (D-), J4.B7 (D-), U1.44 (PA11)
VDD_5V_SERVO: J10.1, J10.2, J10.3, J10.4, J10.5, J10.6, J10.7, J10.8, J10.9, J10.10, JP2.2 (B), JP3.2 (B), R45.1
VDD_5V_USB: C25.1, D4.2 (A), J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS)
VDD_BUCK_5V: C30.1, C31.2, F1.2, L1.2, R1.2, R38.2
VDD_BUCK_6-26_IN: R35.2, R36.1
VDD_BUCK_6-26_OUT: C28.2, C29.2, R35.1, R37.1, U5.5 (EN2), U5.7 (VIN)
VDD_LDO_5V_IN: C33.1, F2.2, U7.3 (VI)
VIDEO_IN: C23.2, J3.3, R14.2
VIDEO_OUT: J5.3, R11.2

## KiCad design Hardware/ciam/impeller18/impeller18.kicad_pcb

Parts:
BT1: DS1092-07-W6L
C1, C2: 2u2; C_0603_1608Metric
C3: 4u7; C_0603_1608Metric
C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C18, C20, C23: 100n; C_0603_1608Metric
C17, C19: 1u; C_0603_1608Metric
C21, C25: 8p; C_0603_1608Metric
C22, C24: 15p; C_0603_1608Metric
H1, H2, H3, H4: M4; MountingHole_4.3mm_M4_Pad_Via
J1: PLS-6; PinHeader_1x06_P2.54mm_Vertical
J2: BH1,27-10-G; PinHeader_2x05_P1.27mm_Vertical
J3, J26: PLS-3; PinHeader_1x03_P2.54mm_Vertical
J29: PLS-8; PinHeader_1x08_P2.54mm_Vertical
JP1: SolderJumper2; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R221, R289, R290, R291: 10k; R_0603_1608Metric
SW1, SW6, SW7, SW8, SW9: B3F1060; SW_PUSH_6mm_H5mm
SW2, SW3: MSS-12D16
TP1, TP2, TP46, TP47: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
U1: STM32F427ZGTx; LQFP-144_20x20mm_P0.5mm
Y1: X322516MLB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: KSE-7K32768KDY2400A3

Connections:
3V3: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C17.1, C18.1, C19.1, C20.1, J1.4, JP1.1 (A), R221.2, R289.2, R290.2, R291.2, SW2.1 (A), SW3.1 (A), U1.17 (VDD), U1.30 (VDD), U1.32 (VREF+), U1.33 (VDDA), U1.39 (VDD), U1.52 (VDD), U1.62 (VDD), U1.72 (VDD), U1.84 (VDD), U1.95 (VDD), U1.108 (VDD), U1.121 (VDD), U1.131 (VDD), U1.143 (PDR_ON), U1.144 (VDD); also elsewhere on the board
3V3_VBAT: C16.1, SW3.2 (B), U1.6 (VBAT)
/BOOT0: R1.1, U1.138 (BOOT0)
/BUTTON_1: R221.1, SW6.1
/BUTTON_2: R289.1, SW7.1
/BUTTON_3: R290.1, SW8.1
/BUTTON_4: R291.1, SW9.1
/HSE_IN: C21.2, TP1.1, U1.23 (PH0), Y1.2
/HSE_OUT: C25.2, U1.24 (PH1), Y1.4
/LSE_IN: C22.2, TP2.1, U1.8 (PC14), Y2.2
/LSE_OUT: C24.2, U1.9 (PC15), Y2.1
/NRST: C23.1, J1.5, J2.10, SW1.1, U1.25 (NRST)
/VCAP_1: C1.1, U1.71 (VCAP_1)
/VCAP_2: C2.1, U1.106 (VCAP_2)
DEBUG_SWD_CLK: J1.3, J2.4, U1.109 (PA14)
DEBUG_SWD_IO: J1.1, J2.2, U1.105 (PA13)
DEBUG_SWD_SWO: J1.6, J2.6, U1.133 (PB3)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.1, C23.2, C24.1, C25.1, J1.2, J2.3, J2.5, J2.9, J3.3, J26.3, J29.8, SW1.2, SW2.3 (C), SW6.2, SW7.2, SW8.2, SW9.2, TP47.1, U1.16 (VSS), U1.31 (VSSA), U1.38 (VSS), U1.51 (VSS), U1.61 (VSS), U1.83 (VSS), U1.94 (VSS), U1.107 (VSS), U1.120 (VSS), U1.130 (VSS), Y1.1, Y1.3; also elsewhere on the board
unnamed: BT1.1 (+), SW3.3 (C), TP46.1
unnamed: J2.1, JP1.2 (B)
unnamed: R1.2, SW2.2 (B)
SDIO_CLK: U1.113 (PC12); also elsewhere on the board
SDIO_CMD: U1.116 (PD2); also elsewhere on the board
SDIO_DAT0: U1.98 (PC8); also elsewhere on the board
SDIO_DAT1: U1.99 (PC9); also elsewhere on the board
SDIO_DAT2: U1.111 (PC10); also elsewhere on the board
SDIO_DAT3: U1.112 (PC11); also elsewhere on the board
SPI1_STM32_ADC8_CS: J29.2; also elsewhere on the board
SPI1_STM32_ADC_BAT_CS: J29.1; also elsewhere on the board
SPI1_STM32_ADC_RUD_CS: J29.3
SPI1_STM32_CLK: J29.5; also elsewhere on the board
SPI1_STM32_FLASH_CS: J29.4; also elsewhere on the board
SPI1_STM32_MISO: J29.7; also elsewhere on the board
SPI1_STM32_MOSI: J29.6; also elsewhere on the board
UART1_STM32_RX: J3.2
UART1_STM32_TX: J3.1
UARTX_STM32_RX: J26.2; also elsewhere on the board
UARTX_STM32_TX: J26.1; also elsewhere on the board
USB_D+: U1.104 (PA12); also elsewhere on the board
USB_D-: U1.103 (PA11); also elsewhere on the board
USB_VBUS: U1.101 (PA9); also elsewhere on the board

Notes on the sheet:
SWD debug connnectors
RESET
VDDA
UART
HSE
VBAT
Вместо X вписать номер (UART1 занят) 1. тут 2. на этом листе где коннекторы 3. в rpi
KSE-7K32768KDY2400A3 32.768 KHz 12.5 pF
VREF
BOOT0
можно поменять на 02х04
POWER SUPPLY
VDD
X322516MLB4SI 16 MHz 9 pF
LSE
VCAP

Parts:
BT2, BT3: Battery_Cell; bat_18350
C26, C33, C133, C134: 4700p; C_1206_3216Metric
C29, C117: 1u; C_0603_1608Metric
C30, C32, C41, C42, C45, C46, C118, C120: 100n; C_0603_1608Metric
C31: 4u7; C_0603_1608Metric
C34, C103, C122: 47u; CP_Radial_D12.5mm_P5.00mm
C35: 68u; CP_Radial_D10.0mm_P5.00mm
C36, C100: 10u; CP_Radial_D10.0mm_P5.00mm
C43, C44, C119: 10u; C_0603_1608Metric
C101, C123, C124, C130, C131, C132: 4u7; C_1210_3225Metric
C102, C125, C126, C127, C128, C129: 10u; C_1210_3225Metric
D1, D2, D3, D6, D7: FYLS-0603BUGC; LED_0603_1608Metric
D4, D5: ss54; D_SMC
F1: MF-LSMF300/24X-2; Fuse_2920_7451Metric
J4: 430450400; 430454000
J30, J31: PLS-2; PinHeader_1x02_P2.54mm_Vertical
K1, K2, K3: 1-1415899-9
L5, L6: B82721-K2222-U30
Q1, Q3, Q4, Q39: BSS138; SOT-23
Q2: AO3401A; SOT-23
R4: 360; R_0603_1608Metric
R5: 220; R_0603_1608Metric
R6, R24, R26: 470; R_0603_1608Metric
R9, R10, R11, R16, R18, R22: 10k; R_0603_1608Metric
R12, R19: 100; R_0603_1608Metric
R13, R14, R20, R21: 130; R_2512_6332Metric
R15: 0m62; R_2512_6332Metric
R17: 1k; R_0603_1608Metric
R23: 120; R_0603_1608Metric
R25: 390; R_0603_1608Metric
R227, R228, R232, R236: PWR_REG; R_0603_1608Metric
R284, R285, R286, R287: 1M; R_0603_1608Metric
TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP39, TP40, TP41, TP42, TP43, TP44, TP45: TestPoint; TestPoint_THTPad_D1.5mm_Drill0.7mm
U2: LDL1117S33R; SOT-223-3_TabPin2
U4: VDRI15W12; VDRI25
U5: MCP3001-I/SN; SOIC-8_3.9x4.9mm_P1.27mm
U6, U10: HY2213-BB3A; SOT-23-6
U7: VDRI25W05; VDRI25
U8: bq2057WSN; SOIC-8_3.9x4.9mm_P1.27mm
U9: LD1084V; TO-220-3_Vertical_radiator

Connections:
3V3: C31.1, C32.1, C117.2, C118.2, C119.2, C120.2, R5.1, TP39.1, U2.2 (VO), U5.1 (VREF), U5.8 (VDD); also elsewhere on the board
5V0: C29.1, C30.1, C35.1, C36.1, D5.1 (K), K1.A1, K2.A1, K3.A1, R4.2, R9.1, R10.1, R227.1, TP11.1, U2.3 (VI), U7.14 (+VOUT); also elsewhere on the board
7V4: C43.1, J31.2, K1.14, K3.11, R287.2, TP10.1, U9.2 (VI)
12V0: C34.1, C100.1, D4.2 (A), R6.1, R232.1, TP9.1, U4.14 (+VOUT); also elsewhere on the board
/Power/BAT_CHRG_TOGGLE_: K2.A2, K3.A2, Q39.3 (D), R9.2
/Power/BAT_RELAY_TOGGLE_: K1.A2, Q1.3 (D), R10.2
BAT_CHRG_STAT: D6.1 (K), D7.2 (A), U8.5 (STAT)
BAT_CHRG_TOGGLE: Q39.1 (G), R16.2
BAT_RELAY_TOGGLE: Q1.1 (G), R11.2
GND: BT3.2 (-), C26.1, C29.2, C30.2, C31.2, C32.2, C33.2, C35.2, C36.2, C42.2, C43.2, C44.2, C45.2, C46.2, C117.1, C118.1, C119.1, C120.1, D1.1 (K), D2.1 (K), D3.1 (K), Q1.2 (S), Q4.2 (S), Q39.2 (S), R11.1, R16.1, R22.1, R25.1, R26.1, R228.2, R286.2, TP12.1, TP13.1, TP14.1, TP41.1, TP42.1, TP45.1, U2.1 (GND), U5.3 (IN-), U5.4 (VSS), U7.16 (-VOUT), U8.6 (VSS), U10.3 (VSS); also elsewhere on the board
GND_12V: C34.2, C100.2, C133.1, C134.2, R236.2, U4.16 (-VOUT); also elsewhere on the board
GND_IN: C33.1, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C134.1, J4.2, J4.4, L5.2, L6.2, TP8.1; also elsewhere on the board
unnamed: BT2.1 (+), F1.2, TP43.1
unnamed: BT2.2 (-), BT3.1 (+), J30.2, K2.11, TP44.1
unnamed: C101.1, C122.1, C123.1, C124.1, L6.4, U4.22 (+VIN), U4.23 (+VIN)
unnamed: C101.2, C122.2, C123.2, C124.2, L6.3, U4.2 (-VIN), U4.3 (-VIN)
unnamed: C102.1, C103.1, C125.1, C126.1, L5.4, U7.22 (+VIN), U7.23 (+VIN)
unnamed: C102.2, C103.2, C125.2, C126.2, L5.3, U7.2 (-VIN), U7.3 (-VIN)
unnamed: D1.2 (A), R4.1
unnamed: D2.2 (A), R5.2
unnamed: D3.2 (A), R6.2
unnamed: C46.1, D4.1 (K), R15.1, R17.2, R18.2, R24.2, U8.3 (VCC), U8.8 (COMP)
unnamed: C44.1, D5.2 (A), R23.1, TP40.1, U9.3 (VO)
unnamed: D6.2 (A), R24.1
unnamed: D7.1 (K), R26.2
unnamed: F1.1, K1.11
unnamed: C41.2, J30.1, K2.14, Q3.2 (S), R19.2, R20.2, R21.1, U6.3 (VSS)
unnamed: Q2.1 (G), R17.1, U8.7 (CC)
unnamed: Q2.2 (S), R15.2, U8.1 (SNS)
unnamed: Q3.3 (D), R13.1, R14.2
unnamed: Q3.1 (G), U6.6 (OUT)
unnamed: Q4.3 (D), R20.1, R21.2
unnamed: Q4.1 (G), U10.6 (OUT)
unnamed: R284.1, R285.2
unnamed: R284.2, R287.1
unnamed: R232.2, R236.1, U4.11 (REG)
unnamed: R285.1, R286.1, U5.2 (IN+)
unnamed: C41.1, R12.1, U6.2 (VDD)
unnamed: R227.2, R228.1, U7.11 (REG)
unnamed: R18.1, R22.2, U8.4 (TS)
unnamed: R23.2, R25.2, U9.1 (ADJ)
unnamed: C45.1, R19.1, U10.2 (VDD)
PACK_CHARGE+: C42.1, J31.1, K3.14, Q2.3 (D), R12.2, R13.2, R14.1, U8.2 (BAT)
SPI1_STM32_ADC_BAT_CS: U5.5 (CS); also elsewhere on the board
SPI1_STM32_CLK: U5.7 (CLK); also elsewhere on the board
SPI1_STM32_MISO: U5.6 (DOUT); also elsewhere on the board
VIN: C26.2, C127.1, C128.1, C129.1, C130.1, C131.1, C132.1, C133.2, J4.1, J4.3, L5.1, L6.1, TP7.1; also elsewhere on the board

Notes on the sheet:
Проверить допуски питания у малины прооверить ss54(падение напряжения)
390-5.31 400-5.4
можно поменять стороны реле
2 м
мб тестовые точки(особенно для земли) сделать как на пьезе чтобы можно было осциллограф цеплять без заморочек?
зарадник: bq2057WSN, на складе: 256 балансировщик: HY2213-BB3A, на складе: 13477 готовое решение: BQ76920, на складе: 110
размыкать питание 5v0 при выключении/отключать всю малину от питания

Parts:
C73: 10u; C_0603_1608Metric
C74: 1u; C_0603_1608Metric
C75: 100n; C_0603_1608Metric
D12, D13: FYLS-3528RGBC; LED_RGB_promelec
F2: MF-LSMF300/24X-2; Fuse_2920_7451Metric
H5, H6, H7, H8: M2.5; MountingHole_2.7mm_M2.5_Pad_Via
J7: Raspberry Pi 4; PinHeader_2x20_P2.54mm_Vertical
J27: PLS-6; PinHeader_1x06_P2.54mm_Vertical
R35, R36, R37, R38, R39, R40: 220; R_0603_1608Metric

Connections:
3V3: D12.2 (A), D13.2 (A); also elsewhere on the board
5V0: F2.2; also elsewhere on the board
CAN0_RPI_INT: J7.16 (GPIO23); also elsewhere on the board
CAN1_RPI_INT: J7.22 (GPIO25); also elsewhere on the board
GND: C73.1, C74.1, C75.1, J7.6 (GND), J7.9 (GND), J7.14 (GND), J7.20 (GND), J7.25 (GND), J7.30 (GND), J7.34 (GND), J7.39 (GND), J27.6; also elsewhere on the board
unnamed: C73.2, C74.2, C75.2, F2.1, J7.2 (5V), J7.4 (5V)
unnamed: D12.3 (BK), R37.1
unnamed: D12.4 (GK), R36.1
unnamed: D12.1 (RK), R35.1
unnamed: D13.3 (BK), R40.1
unnamed: D13.4 (GK), R39.1
unnamed: D13.1 (RK), R38.1
SPI1_RPi_CAN0_CS: J7.24 (~CE0/GPIO8), J27.4; also elsewhere on the board
SPI1_RPi_CAN1_CS: J7.26 (~CE1/GPIO7), J27.5; also elsewhere on the board
SPI1_RPi_MISO: J7.21 (MISO0/GPIO9), J27.3; also elsewhere on the board
SPI1_RPi_MOSI: J7.19 (MOSI0/GPIO10), J27.2; also elsewhere on the board
SPI1_RPi_SCK: J7.23 (SCLK0/GPIO11), J27.1; also elsewhere on the board
UARTX_STM32_RX: J7.8 (GPIO14/TXD); also elsewhere on the board
UARTX_STM32_TX: J7.10 (GPIO15/RXD); also elsewhere on the board

Notes on the sheet:
можно поменять на 02х03
ДОБАВИТЬ СИГНАЛ О ВОЗМОЖНОСТИ ВЫКЛЮЧЕНИИ ПИТАНИЯ
когда подключим светодиоды?
